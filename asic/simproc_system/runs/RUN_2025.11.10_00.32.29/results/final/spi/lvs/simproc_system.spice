* NGSPICE file created from simproc_system.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_1 abstract view
.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_4 abstract view
.subckt sky130_fd_sc_hd__a22oi_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_2 abstract view
.subckt sky130_fd_sc_hd__a22o_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32oi_2 abstract view
.subckt sky130_fd_sc_hd__a32oi_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_2 abstract view
.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_2 abstract view
.subckt sky130_fd_sc_hd__a211o_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_2 abstract view
.subckt sky130_fd_sc_hd__o211a_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_4 abstract view
.subckt sky130_fd_sc_hd__or4b_4 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_4 abstract view
.subckt sky130_fd_sc_hd__o31ai_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_4 abstract view
.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_4 abstract view
.subckt sky130_fd_sc_hd__and4b_4 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_4 abstract view
.subckt sky130_fd_sc_hd__o21a_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_1 abstract view
.subckt sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_4 abstract view
.subckt sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_4 abstract view
.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_4 abstract view
.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_2 abstract view
.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_4 abstract view
.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_2 abstract view
.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_4 abstract view
.subckt sky130_fd_sc_hd__nand3b_4 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_4 abstract view
.subckt sky130_fd_sc_hd__a221o_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_4 abstract view
.subckt sky130_fd_sc_hd__a22o_4 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_4 abstract view
.subckt sky130_fd_sc_hd__a221oi_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_4 abstract view
.subckt sky130_fd_sc_hd__a211oi_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41ai_1 abstract view
.subckt sky130_fd_sc_hd__o41ai_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_2 abstract view
.subckt sky130_fd_sc_hd__a32o_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_2 abstract view
.subckt sky130_fd_sc_hd__a2111o_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_2 abstract view
.subckt sky130_fd_sc_hd__and3b_2 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_4 abstract view
.subckt sky130_fd_sc_hd__o31a_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_2 abstract view
.subckt sky130_fd_sc_hd__o31ai_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_4 abstract view
.subckt sky130_fd_sc_hd__a211o_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_4 abstract view
.subckt sky130_fd_sc_hd__o311a_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41a_1 abstract view
.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_4 abstract view
.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

.subckt simproc_system VGND VPWR addr_byte[0] addr_byte[1] addr_byte[2] addr_byte[3]
+ addr_byte[4] addr_byte[5] addr_byte[6] addr_byte[7] clk clk_per_bit[0] clk_per_bit[1]
+ clk_per_bit[2] clk_per_bit[3] clk_per_bit[4] clk_per_bit[5] clk_per_bit[6] clk_per_bit[7]
+ clk_per_bit[8] clk_per_bit[9] cmd_byte[0] cmd_byte[1] cmd_byte[2] cmd_byte[3] cmd_byte[4]
+ cmd_byte[5] cmd_byte[6] cmd_byte[7] data_byte[0] data_byte[1] data_byte[2] data_byte[3]
+ data_byte[4] data_byte[5] data_byte[6] data_byte[7] done halt rst tx_reg[0] tx_reg[1]
+ tx_reg[2] tx_reg[3] tx_reg[4] tx_reg[5] tx_reg[6] tx_reg[7] uart_rx uart_tx
X_3086_ _0961_ _1017_ VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3155_ CPU1.PC1.pc_out\[7\] _0941_ _1091_ _1092_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__o211a_1
X_2939_ _0826_ _0833_ _0888_ _0889_ net93 VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__a32o_1
XFILLER_0_76_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3988_ _2004_ _1688_ _1694_ UART1.UART_RX1.index\[2\] VGND VGND VPWR VPWR _1745_
+ sky130_fd_sc_hd__or4bb_1
XFILLER_0_7_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_58 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_58_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3842_ RAM1.mem\[7\]\[3\] _0389_ _1630_ VGND VGND VPWR VPWR _1639_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3911_ _1686_ _0416_ _1672_ VGND VGND VPWR VPWR _1687_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3773_ _0452_ _1589_ _1575_ VGND VGND VPWR VPWR _1590_ sky130_fd_sc_hd__mux2_1
X_2724_ _1923_ _0716_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__and2_1
X_2655_ RAM1.mem\[14\]\[2\] _0581_ _0587_ RAM1.mem\[15\]\[2\] _0589_ VGND VGND VPWR
+ VPWR _0650_ sky130_fd_sc_hd__a221o_1
X_4325_ clknet_leaf_6_clk _0113_ VGND VGND VPWR VPWR CPU1.RF1.rf\[1\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_3207_ _0459_ VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__clkbuf_4
X_2586_ _0496_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__buf_4
X_4187_ UART1.UART_TX1.clkCount\[6\] VGND VGND VPWR VPWR _1898_ sky130_fd_sc_hd__inv_2
XFILLER_0_1_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_185 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4256_ clknet_leaf_23_clk _0051_ VGND VGND VPWR VPWR RAM1.mem\[11\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_3069_ _0906_ _0993_ _0915_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__o21a_1
XFILLER_0_49_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3138_ net150 _0941_ _1076_ _0569_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__o211a_1
XFILLER_0_49_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_49 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_70_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_206 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2440_ RAM1.mem\[10\]\[5\] _0479_ _0462_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__mux2_1
X_2371_ _2067_ RAM1.mem\[0\]\[0\] _0423_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__mux2_1
XFILLER_0_59_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4041_ _1783_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__clkbuf_1
X_4110_ _1836_ _0398_ _1828_ VGND VGND VPWR VPWR _1837_ sky130_fd_sc_hd__mux2_1
XFILLER_0_86_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3756_ _1578_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__clkbuf_1
X_3825_ _0449_ _1626_ _1614_ VGND VGND VPWR VPWR _1627_ sky130_fd_sc_hd__mux2_1
X_2638_ RAM1.mem\[0\]\[1\] RAM1.mem\[1\]\[1\] _0592_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__mux2_1
X_3687_ _1534_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_71_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2707_ _0595_ _0699_ VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__or2_1
XFILLER_0_40_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2569_ net139 _1932_ _0567_ _0557_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__o211a_1
X_4239_ clknet_leaf_12_clk _0034_ VGND VGND VPWR VPWR RAM1.mem\[0\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_65_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4308_ clknet_leaf_24_clk _0096_ VGND VGND VPWR VPWR UART1.UART_RX1.clkCount\[1\]
+ sky130_fd_sc_hd__dfxtp_2
XFILLER_0_37_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3610_ _1480_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_9_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4590_ clknet_leaf_25_clk _0367_ VGND VGND VPWR VPWR UART1.UART_TX1.clkCount\[1\]
+ sky130_fd_sc_hd__dfxtp_1
X_3541_ _0408_ RAM1.mem\[20\]\[6\] _1417_ VGND VGND VPWR VPWR _1431_ sky130_fd_sc_hd__mux2_1
X_2423_ _2101_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__clkbuf_8
X_3472_ _2102_ RAM1.mem\[9\]\[1\] _1378_ VGND VGND VPWR VPWR _1383_ sky130_fd_sc_hd__mux2_1
X_2285_ _2061_ CPU1.PC1.pc_out\[4\] net51 CPU1.reg_b_out\[4\] VGND VGND VPWR VPWR
+ _2070_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_50_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4024_ _1377_ _1770_ VGND VGND VPWR VPWR _1771_ sky130_fd_sc_hd__nand2_4
X_2354_ _0408_ RAM1.mem\[8\]\[6\] _2081_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3739_ _0446_ _1565_ _1555_ VGND VGND VPWR VPWR _1566_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3808_ _1615_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_34_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2972_ CPU1.reg_a_out\[1\] _0902_ _0904_ CPU1.PC1.pc_out\[1\] VGND VGND VPWR VPWR
+ _0917_ sky130_fd_sc_hd__a22o_2
XFILLER_0_48_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4573_ clknet_leaf_4_clk _0350_ VGND VGND VPWR VPWR CPU1.reg_b_out\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_71_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2406_ _0416_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__buf_2
X_3386_ net95 _1113_ _1307_ _1308_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__o211a_1
X_3455_ _2062_ _1278_ VGND VGND VPWR VPWR _1371_ sky130_fd_sc_hd__nand2_1
X_3524_ _1418_ _2088_ _1419_ VGND VGND VPWR VPWR _1420_ sky130_fd_sc_hd__mux2_1
X_2268_ _2055_ VGND VGND VPWR VPWR _2056_ sky130_fd_sc_hd__buf_2
X_4007_ _1759_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__clkbuf_1
X_2199_ UART1.UART_RX1.clkCount\[4\] _1961_ _1993_ _1994_ _1995_ VGND VGND VPWR VPWR
+ _1996_ sky130_fd_sc_hd__o221a_1
X_2337_ _0394_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold63 CPU1.RF1.rf\[1\]\[0\] VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__dlygate4sd3_1
Xhold41 CPU1.RF1.rf\[0\]\[5\] VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__dlygate4sd3_1
Xhold30 CPU1.RF1.rf\[3\]\[5\] VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__dlygate4sd3_1
Xhold74 UART1.UART_TX1.packet\[5\] VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold52 UART1.UART_RX1.dataOut\[3\] VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold85 UART1.UART_TX1.packet\[8\] VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__dlygate4sd3_1
Xhold96 UART1.UART_RX1.state\[2\] VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_53_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_5 net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3240_ RAM1.mem\[20\]\[1\] RAM1.mem\[21\]\[1\] _1119_ VGND VGND VPWR VPWR _1167_
+ sky130_fd_sc_hd__mux2_1
XTAP_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3171_ _1094_ _0988_ VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__nand2_1
X_2122_ _1919_ _1929_ VGND VGND VPWR VPWR _1930_ sky130_fd_sc_hd__nand2_1
XTAP_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2955_ _0899_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__buf_2
XFILLER_0_29_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3507_ _0440_ _1407_ _1401_ VGND VGND VPWR VPWR _1408_ sky130_fd_sc_hd__mux2_1
X_2886_ _0846_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__buf_2
X_4556_ clknet_leaf_3_clk _0333_ VGND VGND VPWR VPWR RAM1.mem\[14\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_234 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_32_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4487_ clknet_leaf_13_clk _0266_ VGND VGND VPWR VPWR RAM1.mem\[4\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_3438_ RAM1.mem\[6\]\[7\] _0459_ _1114_ _1358_ VGND VGND VPWR VPWR _1359_ sky130_fd_sc_hd__o211a_1
X_3369_ RAM1.mem\[12\]\[5\] RAM1.mem\[13\]\[5\] _1118_ VGND VGND VPWR VPWR _1292_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput42 net42 VGND VGND VPWR VPWR tx_reg[3] sky130_fd_sc_hd__clkbuf_4
Xoutput31 net31 VGND VGND VPWR VPWR data_byte[2] sky130_fd_sc_hd__clkbuf_4
Xoutput20 net20 VGND VGND VPWR VPWR addr_byte[7] sky130_fd_sc_hd__clkbuf_4
XPHY_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2740_ _0580_ _0726_ _0727_ _0731_ _0426_ VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__a311o_1
X_2671_ RAM1.mem\[20\]\[2\] RAM1.mem\[21\]\[2\] _0592_ VGND VGND VPWR VPWR _0666_
+ sky130_fd_sc_hd__mux2_1
X_4410_ clknet_leaf_16_clk _0189_ VGND VGND VPWR VPWR RAM1.mem\[20\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_4341_ clknet_leaf_6_clk _0129_ VGND VGND VPWR VPWR CPU1.reg_a_out\[7\] sky130_fd_sc_hd__dfxtp_1
X_3223_ RAM1.mem\[1\]\[0\] _2075_ VGND VGND VPWR VPWR _1151_ sky130_fd_sc_hd__or2_1
X_4272_ clknet_leaf_2_clk _0063_ VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__dfxtp_4
X_3085_ _0901_ _1024_ _1025_ _0956_ VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__o211a_1
X_3154_ _2063_ VGND VGND VPWR VPWR _1092_ sky130_fd_sc_hd__clkbuf_4
X_2938_ _0826_ _0832_ _0888_ _0889_ net77 VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__a32o_1
XFILLER_0_64_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3987_ net115 _1720_ _1744_ _1308_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__o211a_1
XFILLER_0_17_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2869_ CPU1.instr_reg_out\[6\] _2046_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__nand2_1
XFILLER_0_32_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4539_ clknet_leaf_26_clk _0316_ VGND VGND VPWR VPWR UART1.RX_dataOut\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3841_ _1638_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__clkbuf_1
X_3772_ _0414_ RAM1.mem\[4\]\[7\] _1572_ VGND VGND VPWR VPWR _1589_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3910_ RAM1.mem\[15\]\[7\] _0485_ _1669_ VGND VGND VPWR VPWR _1686_ sky130_fd_sc_hd__mux2_1
X_2723_ _0521_ _0702_ _0709_ _0715_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__a31o_1
XFILLER_0_13_63 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4324_ clknet_leaf_5_clk _0112_ VGND VGND VPWR VPWR CPU1.RF1.rf\[3\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_2585_ _0581_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__buf_4
X_2654_ RAM1.mem\[10\]\[2\] _0581_ _0587_ RAM1.mem\[11\]\[2\] _0584_ VGND VGND VPWR
+ VPWR _0649_ sky130_fd_sc_hd__a221o_1
X_3206_ _1116_ VGND VGND VPWR VPWR _1134_ sky130_fd_sc_hd__clkbuf_4
X_3137_ net19 _0936_ _1075_ _0905_ _0937_ VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__a221o_1
XFILLER_0_38_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4255_ clknet_leaf_23_clk _0050_ VGND VGND VPWR VPWR RAM1.mem\[11\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_4186_ UART1.UART_TX1.clkCount\[6\] _1892_ VGND VGND VPWR VPWR _1897_ sky130_fd_sc_hd__nor2_1
X_3068_ _0906_ _0993_ _0923_ VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_64_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_34_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2370_ _2080_ _0422_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__nand2_4
X_4040_ _0399_ _1782_ _1774_ VGND VGND VPWR VPWR _1783_ sky130_fd_sc_hd__mux2_1
XFILLER_0_91_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3755_ _0434_ _1577_ _1575_ VGND VGND VPWR VPWR _1578_ sky130_fd_sc_hd__mux2_1
X_3686_ _0419_ _1531_ _1533_ VGND VGND VPWR VPWR _1534_ sky130_fd_sc_hd__mux2_1
X_3824_ RAM1.mem\[6\]\[6\] _0407_ _1611_ VGND VGND VPWR VPWR _1626_ sky130_fd_sc_hd__mux2_1
X_2706_ RAM1.mem\[8\]\[4\] RAM1.mem\[9\]\[4\] _0596_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__mux2_1
X_2637_ RAM1.mem\[4\]\[1\] RAM1.mem\[5\]\[1\] _0593_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__mux2_1
X_2499_ _0434_ _0526_ _0524_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__mux2_1
XFILLER_0_64_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2568_ net35 _0560_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__or2_1
X_4307_ clknet_leaf_24_clk _0095_ VGND VGND VPWR VPWR UART1.UART_RX1.clkCount\[0\]
+ sky130_fd_sc_hd__dfxtp_2
XFILLER_0_10_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4238_ clknet_leaf_11_clk _0033_ VGND VGND VPWR VPWR RAM1.mem\[0\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_69_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4169_ _2058_ _1883_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__nor2_1
XFILLER_0_68_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3540_ _1430_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_51_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2353_ _0407_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__buf_4
X_2422_ _0466_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__clkbuf_1
X_3471_ _1382_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__clkbuf_1
X_2284_ _2068_ VGND VGND VPWR VPWR _2069_ sky130_fd_sc_hd__clkbuf_4
X_4023_ _1131_ _2072_ VGND VGND VPWR VPWR _1770_ sky130_fd_sc_hd__nor2_2
XFILLER_0_19_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3738_ RAM1.mem\[3\]\[5\] _0401_ _1552_ VGND VGND VPWR VPWR _1565_ sky130_fd_sc_hd__mux2_1
X_3807_ _0419_ _1612_ _1614_ VGND VGND VPWR VPWR _1615_ sky130_fd_sc_hd__mux2_1
X_3669_ RAM1.mem\[23\]\[4\] _0476_ _1511_ VGND VGND VPWR VPWR _1521_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_195 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2971_ _2029_ _0895_ _0896_ _0915_ CPU1.instr_reg_out\[4\] VGND VGND VPWR VPWR _0916_
+ sky130_fd_sc_hd__a32oi_2
XFILLER_0_8_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4572_ clknet_leaf_6_clk _0349_ VGND VGND VPWR VPWR CPU1.reg_b_out\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_71_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3523_ _2098_ _0522_ VGND VGND VPWR VPWR _1419_ sky130_fd_sc_hd__nor2_4
XFILLER_0_12_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2405_ _0451_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__clkbuf_1
X_3454_ _1365_ _2032_ _1366_ _1370_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__o211a_1
X_2336_ _0391_ _0393_ _2099_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__mux2_1
X_3385_ _2063_ VGND VGND VPWR VPWR _1308_ sky130_fd_sc_hd__clkbuf_4
X_2267_ CPU1.curr_state\[2\] VGND VGND VPWR VPWR _2055_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_46_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4006_ _0387_ _1758_ _1754_ VGND VGND VPWR VPWR _1759_ sky130_fd_sc_hd__mux2_1
X_2198_ UART1.UART_RX1.clkCount\[5\] _1973_ VGND VGND VPWR VPWR _1995_ sky130_fd_sc_hd__or2_1
XFILLER_0_27_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold64 CPU1.RF1.rf\[1\]\[1\] VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__dlygate4sd3_1
Xhold31 CPU1.RF1.rf\[2\]\[7\] VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold53 CPU1.RF1.rf\[1\]\[7\] VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__dlygate4sd3_1
Xhold20 CPU1.alu_reg_out\[4\] VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__dlygate4sd3_1
Xhold42 CPU1.mdr_out\[5\] VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__dlygate4sd3_1
Xhold97 CPU1.PC1.pc_out\[6\] VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__dlygate4sd3_1
Xhold75 _1915_ VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__dlygate4sd3_1
Xhold86 UART1.RX_dataOut\[6\] VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_6 net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3170_ _1103_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__clkbuf_1
XTAP_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2121_ _1923_ _1926_ _1928_ VGND VGND VPWR VPWR _1929_ sky130_fd_sc_hd__or3b_1
X_2885_ _2029_ _2059_ CPU1.curr_state\[2\] VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__a21o_2
X_2954_ _2028_ _0895_ _0896_ _0898_ CPU1.instr_reg_out\[4\] VGND VGND VPWR VPWR _0899_
+ sky130_fd_sc_hd__a32o_1
XFILLER_0_44_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_51 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4486_ clknet_leaf_12_clk _0265_ VGND VGND VPWR VPWR RAM1.mem\[4\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_3506_ _0390_ RAM1.mem\[21\]\[3\] _1398_ VGND VGND VPWR VPWR _1407_ sky130_fd_sc_hd__mux2_1
X_4555_ clknet_leaf_9_clk _0332_ VGND VGND VPWR VPWR RAM1.mem\[14\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3437_ RAM1.mem\[7\]\[7\] _2074_ VGND VGND VPWR VPWR _1358_ sky130_fd_sc_hd__or2_1
X_3299_ RAM1.mem\[20\]\[3\] RAM1.mem\[21\]\[3\] _1138_ VGND VGND VPWR VPWR _1224_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3368_ _1116_ _1288_ _1290_ _2069_ VGND VGND VPWR VPWR _1291_ sky130_fd_sc_hd__a211o_2
X_2319_ _2102_ RAM1.mem\[8\]\[1\] _2081_ VGND VGND VPWR VPWR _2103_ sky130_fd_sc_hd__mux2_1
XFILLER_0_35_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput43 net43 VGND VGND VPWR VPWR tx_reg[4] sky130_fd_sc_hd__clkbuf_4
Xoutput21 net21 VGND VGND VPWR VPWR cmd_byte[0] sky130_fd_sc_hd__clkbuf_4
Xoutput32 net32 VGND VGND VPWR VPWR data_byte[3] sky130_fd_sc_hd__clkbuf_4
XPHY_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4340_ clknet_leaf_7_clk _0128_ VGND VGND VPWR VPWR CPU1.reg_a_out\[6\] sky130_fd_sc_hd__dfxtp_1
X_2670_ _0663_ _0664_ _0578_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__mux2_1
X_3222_ RAM1.mem\[2\]\[0\] RAM1.mem\[3\]\[0\] _0459_ VGND VGND VPWR VPWR _1150_ sky130_fd_sc_hd__mux2_1
X_3153_ net20 _0936_ _1090_ _0905_ _0937_ VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__a221o_1
X_4271_ clknet_leaf_1_clk _0062_ VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__dfxtp_2
X_3084_ _0901_ _0984_ VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2937_ _0826_ _0830_ _0888_ _0889_ net72 VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__a32o_1
XFILLER_0_94_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2868_ _0824_ _0825_ _0838_ _0831_ net58 VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__a32o_1
X_3986_ _2005_ _1743_ _1719_ VGND VGND VPWR VPWR _1744_ sky130_fd_sc_hd__a21bo_1
X_4469_ clknet_leaf_5_clk _0248_ VGND VGND VPWR VPWR CPU1.RF1.rf\[0\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_68_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2799_ _0521_ _0773_ _0780_ _0788_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__a31o_1
XFILLER_0_2_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4538_ clknet_leaf_0_clk _0315_ VGND VGND VPWR VPWR UART1.RX_dataOut\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_99_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3771_ _1588_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3840_ _0437_ _1637_ _1633_ VGND VGND VPWR VPWR _1638_ sky130_fd_sc_hd__mux2_1
X_2722_ _2092_ _0712_ _0714_ _0430_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__o211a_1
XFILLER_0_13_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4323_ clknet_leaf_5_clk _0111_ VGND VGND VPWR VPWR CPU1.RF1.rf\[3\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_2584_ _0492_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__clkbuf_4
X_2653_ net40 _0575_ _0648_ _0569_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__o211a_1
XFILLER_0_1_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3136_ _0924_ _1068_ _1071_ _1074_ VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__a211o_1
X_3067_ _0963_ _1008_ _0900_ VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__mux2_1
X_3205_ _1117_ _1127_ _1130_ _1132_ VGND VGND VPWR VPWR _1133_ sky130_fd_sc_hd__o211a_2
X_4254_ clknet_leaf_20_clk _0049_ VGND VGND VPWR VPWR RAM1.mem\[11\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_4185_ UART1.UART_TX1.clkCount\[6\] _1892_ VGND VGND VPWR VPWR _1896_ sky130_fd_sc_hd__and2_1
XFILLER_0_64_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3969_ _2004_ UART1.UART_RX1.index\[2\] UART1.UART_RX1.index\[0\] _1694_ VGND VGND
+ VPWR VPWR _1730_ sky130_fd_sc_hd__or4b_1
XFILLER_0_20_208 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_59_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3823_ _1625_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_86_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3754_ _2102_ RAM1.mem\[4\]\[1\] _1572_ VGND VGND VPWR VPWR _1577_ sky130_fd_sc_hd__mux2_1
X_2636_ RAM1.mem\[6\]\[1\] _0586_ _0583_ RAM1.mem\[7\]\[1\] _0605_ VGND VGND VPWR
+ VPWR _0632_ sky130_fd_sc_hd__a221o_1
X_3685_ _1532_ VGND VGND VPWR VPWR _1533_ sky130_fd_sc_hd__clkbuf_4
X_2705_ RAM1.mem\[12\]\[4\] RAM1.mem\[13\]\[4\] _0593_ VGND VGND VPWR VPWR _0698_
+ sky130_fd_sc_hd__mux2_1
X_4237_ clknet_leaf_11_clk _0032_ VGND VGND VPWR VPWR RAM1.mem\[0\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_2498_ RAM1.mem\[22\]\[1\] _0467_ _0519_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4306_ clknet_leaf_1_clk _0094_ VGND VGND VPWR VPWR run_reg sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2567_ net120 _1932_ _0566_ _0557_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__o211a_1
X_3119_ CPU1.reg_b_out\[6\] _2051_ _1039_ VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__o21a_1
X_4099_ _1829_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__clkbuf_1
X_4168_ _1873_ _1880_ _1881_ _1874_ _1882_ VGND VGND VPWR VPWR _1883_ sky130_fd_sc_hd__o32a_1
XFILLER_0_92_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_45_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2352_ _2049_ CPU1.reg_a_out\[6\] _2065_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__and3_2
X_2283_ _2061_ CPU1.PC1.pc_out\[2\] net172 CPU1.reg_b_out\[2\] VGND VGND VPWR VPWR
+ _2068_ sky130_fd_sc_hd__a22o_1
X_2421_ _0463_ _2088_ _0465_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__mux2_1
X_3470_ _1379_ _2088_ _1381_ VGND VGND VPWR VPWR _1382_ sky130_fd_sc_hd__mux2_1
X_4022_ _1769_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_35_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3806_ _1613_ VGND VGND VPWR VPWR _1614_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_51_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3737_ _1564_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__clkbuf_1
X_3668_ _1520_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__clkbuf_1
X_2619_ RAM1.mem\[20\]\[0\] RAM1.mem\[21\]\[0\] _0495_ VGND VGND VPWR VPWR _0616_
+ sky130_fd_sc_hd__mux2_1
X_3599_ RAM1.mem\[18\]\[7\] _0485_ _1455_ VGND VGND VPWR VPWR _1472_ sky130_fd_sc_hd__mux2_1
XFILLER_0_100_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_203 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2970_ _0898_ VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_71_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4571_ clknet_leaf_6_clk _0348_ VGND VGND VPWR VPWR CPU1.reg_b_out\[4\] sky130_fd_sc_hd__dfxtp_2
X_3453_ _2062_ _1250_ VGND VGND VPWR VPWR _1370_ sky130_fd_sc_hd__nand2_1
X_3522_ _2067_ RAM1.mem\[20\]\[0\] _1417_ VGND VGND VPWR VPWR _1418_ sky130_fd_sc_hd__mux2_1
XFILLER_0_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2404_ _0449_ _0450_ _0432_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__mux2_1
X_3384_ _1112_ _1306_ VGND VGND VPWR VPWR _1307_ sky130_fd_sc_hd__nand2_1
X_2335_ _0392_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__buf_4
X_2266_ _2054_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4005_ RAM1.mem\[14\]\[2\] _2107_ _1751_ VGND VGND VPWR VPWR _1758_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2197_ UART1.UART_RX1.clkCount\[3\] _1964_ _1961_ UART1.UART_RX1.clkCount\[4\] VGND
+ VGND VPWR VPWR _1994_ sky130_fd_sc_hd__a22o_1
XFILLER_0_62_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_299 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold43 CPU1.RF1.rf\[2\]\[6\] VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__dlygate4sd3_1
Xhold98 CPU1.reg_a_out\[4\] VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__dlygate4sd3_1
Xhold10 CPU1.RF1.rf\[3\]\[6\] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 CPU1.mdr_out\[0\] VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__dlygate4sd3_1
Xhold76 UART1.UART_TX1.packet\[6\] VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__dlygate4sd3_1
Xhold87 UART1.TX_en VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__dlygate4sd3_1
Xhold65 UART1.RX_dataOut\[4\] VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__buf_1
Xhold54 UART1.UART_RX1.dataOut\[1\] VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__dlygate4sd3_1
Xhold32 uart_curr_state\[0\] VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_85_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_7 net35 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2120_ net22 _1927_ net21 _1924_ VGND VGND VPWR VPWR _1928_ sky130_fd_sc_hd__or4b_1
XTAP_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2953_ _0897_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__clkbuf_4
X_2884_ _0845_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3505_ _1406_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__clkbuf_1
X_4485_ clknet_leaf_12_clk _0264_ VGND VGND VPWR VPWR RAM1.mem\[4\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_3436_ RAM1.mem\[4\]\[7\] RAM1.mem\[5\]\[7\] _0458_ VGND VGND VPWR VPWR _1357_ sky130_fd_sc_hd__mux2_1
X_4554_ clknet_leaf_3_clk _0331_ VGND VGND VPWR VPWR RAM1.mem\[14\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2318_ _2101_ VGND VGND VPWR VPWR _2102_ sky130_fd_sc_hd__buf_4
X_3298_ net76 _1113_ _1223_ _1092_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__o211a_1
XFILLER_0_57_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2249_ CPU1.instr_reg_out\[2\] CPU1.instr_reg_out\[1\] _2031_ CPU1.instr_reg_out\[3\]
+ VGND VGND VPWR VPWR _2042_ sky130_fd_sc_hd__or4b_4
X_3367_ RAM1.mem\[8\]\[5\] _1144_ _1139_ _1289_ VGND VGND VPWR VPWR _1290_ sky130_fd_sc_hd__o211a_1
XFILLER_0_79_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput22 net22 VGND VGND VPWR VPWR cmd_byte[1] sky130_fd_sc_hd__clkbuf_4
Xoutput44 net44 VGND VGND VPWR VPWR tx_reg[5] sky130_fd_sc_hd__clkbuf_4
Xoutput33 net33 VGND VGND VPWR VPWR data_byte[4] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_9_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4270_ clknet_leaf_13_clk _0061_ VGND VGND VPWR VPWR RAM1.mem\[22\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_3152_ _1082_ _1083_ _1089_ VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__o21ai_2
X_3083_ _0906_ _0961_ _0910_ VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__mux2_1
X_3221_ _0420_ VGND VGND VPWR VPWR _1149_ sky130_fd_sc_hd__buf_2
XFILLER_0_27_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3985_ UART1.UART_RX1.dataOut\[5\] _1741_ _1742_ _1725_ VGND VGND VPWR VPWR _1743_
+ sky130_fd_sc_hd__a22o_1
X_2936_ _1951_ _0888_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__nor2_2
XFILLER_0_87_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2867_ CPU1.mdr_out\[7\] _0827_ _0829_ CPU1.alu_reg_out\[7\] VGND VGND VPWR VPWR
+ _0838_ sky130_fd_sc_hd__a22o_2
X_2798_ _2092_ _0783_ _0787_ _0430_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__o211a_1
X_4606_ clknet_leaf_2_clk _0383_ VGND VGND VPWR VPWR UART1.UART_TX1.packet\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4468_ clknet_leaf_6_clk _0247_ VGND VGND VPWR VPWR CPU1.RF1.rf\[0\]\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3419_ _1134_ _1337_ _1339_ _1125_ VGND VGND VPWR VPWR _1340_ sky130_fd_sc_hd__o211a_1
X_4399_ clknet_leaf_16_clk _0178_ VGND VGND VPWR VPWR RAM1.mem\[9\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_4537_ clknet_leaf_0_clk _0314_ VGND VGND VPWR VPWR UART1.RX_dataOut\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_46_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3770_ _0449_ _1587_ _1575_ VGND VGND VPWR VPWR _1588_ sky130_fd_sc_hd__mux2_1
X_2721_ _0591_ _0713_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__or2_1
X_2652_ net157 _1926_ _0646_ _1923_ _0647_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__a221o_1
XFILLER_0_14_239 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4322_ clknet_leaf_5_clk _0110_ VGND VGND VPWR VPWR CPU1.RF1.rf\[3\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_2583_ _0579_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__clkbuf_4
X_3204_ _1131_ VGND VGND VPWR VPWR _1132_ sky130_fd_sc_hd__clkbuf_4
X_4253_ clknet_leaf_24_clk _0048_ VGND VGND VPWR VPWR RAM1.mem\[11\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_3135_ _0953_ _0894_ _1031_ _1073_ VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__a31o_1
X_3066_ _0972_ _1007_ _0913_ VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4184_ _2058_ _1895_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__nor2_1
X_2919_ CPU1.RF1.rf\[0\]\[5\] _0850_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__or2_1
XFILLER_0_49_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3968_ net107 _1720_ _1729_ _1308_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__o211a_1
XFILLER_0_72_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3899_ _1678_ _0392_ _1672_ VGND VGND VPWR VPWR _1679_ sky130_fd_sc_hd__mux2_1
XFILLER_0_91_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3822_ _0446_ _1624_ _1614_ VGND VGND VPWR VPWR _1625_ sky130_fd_sc_hd__mux2_1
XFILLER_0_86_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_46_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3753_ _1576_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__clkbuf_1
X_2635_ RAM1.mem\[2\]\[1\] _0582_ _0497_ RAM1.mem\[3\]\[1\] _0428_ VGND VGND VPWR
+ VPWR _0631_ sky130_fd_sc_hd__a221o_1
X_3684_ _0426_ _0428_ _0429_ _0464_ VGND VGND VPWR VPWR _1532_ sky130_fd_sc_hd__or4_1
X_2704_ RAM1.mem\[14\]\[4\] _0581_ _0587_ RAM1.mem\[15\]\[4\] _0589_ VGND VGND VPWR
+ VPWR _0697_ sky130_fd_sc_hd__a221o_1
XFILLER_0_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4236_ clknet_leaf_12_clk _0031_ VGND VGND VPWR VPWR RAM1.mem\[0\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_2497_ _0525_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__clkbuf_1
X_4305_ clknet_leaf_2_clk _0002_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4167_ UART1.UART_TX1.clkCount\[2\] VGND VGND VPWR VPWR _1882_ sky130_fd_sc_hd__inv_2
X_2566_ net34 _0560_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__or2_1
X_3118_ _1007_ VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__inv_2
XFILLER_0_77_242 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3049_ CPU1.instr_reg_out\[7\] _2036_ _2044_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__a21o_1
X_4098_ _1827_ _2087_ _1828_ VGND VGND VPWR VPWR _1829_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2420_ _2094_ _0464_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__nor2_4
XFILLER_0_86_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4021_ _0417_ _1768_ _1754_ VGND VGND VPWR VPWR _1769_ sky130_fd_sc_hd__mux2_1
X_2282_ _2066_ VGND VGND VPWR VPWR _2067_ sky130_fd_sc_hd__clkbuf_4
X_2351_ _0406_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3736_ _0443_ _1563_ _1555_ VGND VGND VPWR VPWR _1564_ sky130_fd_sc_hd__mux2_1
X_3805_ _0425_ _0615_ _0429_ _0464_ VGND VGND VPWR VPWR _1613_ sky130_fd_sc_hd__or4_1
XFILLER_0_59_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3667_ _1519_ _0392_ _1513_ VGND VGND VPWR VPWR _1520_ sky130_fd_sc_hd__mux2_1
X_2618_ _0588_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__buf_2
XFILLER_0_42_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3598_ _1471_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__clkbuf_1
X_2549_ _2063_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__buf_2
XFILLER_0_97_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4219_ _1918_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_65_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_215 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_65_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_18_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4570_ clknet_leaf_6_clk _0347_ VGND VGND VPWR VPWR CPU1.reg_b_out\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_56_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2403_ _0408_ RAM1.mem\[0\]\[6\] _0423_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__mux2_1
X_3521_ _2080_ _1397_ VGND VGND VPWR VPWR _1417_ sky130_fd_sc_hd__nand2_4
X_3383_ _0516_ _1283_ _1287_ _1305_ VGND VGND VPWR VPWR _1306_ sky130_fd_sc_hd__o31ai_4
X_3452_ _1365_ _2033_ _1366_ _1369_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__o211a_1
XFILLER_0_24_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4004_ _1757_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__clkbuf_1
X_2196_ UART1.UART_RX1.clkCount\[3\] _1964_ _1967_ UART1.UART_RX1.clkCount\[2\] _1992_
+ VGND VGND VPWR VPWR _1993_ sky130_fd_sc_hd__o221a_1
X_2334_ net32 _1941_ _2086_ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__and3_4
X_2265_ _1939_ UART1.UART_TX1.state\[2\] _1953_ _1986_ VGND VGND VPWR VPWR _2054_
+ sky130_fd_sc_hd__and4_1
XFILLER_0_94_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3719_ _0838_ _1550_ _1551_ net67 VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__a22o_1
XFILLER_0_30_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold11 CPU1.RF1.rf\[3\]\[4\] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__dlygate4sd3_1
Xhold22 CPU1.mdr_out\[7\] VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__dlygate4sd3_1
Xhold99 CPU1.reg_a_out\[5\] VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__dlygate4sd3_1
Xhold33 CPU1.reg_b_out\[6\] VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__dlygate4sd3_1
Xhold44 CPU1.reg_b_out\[7\] VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dlygate4sd3_1
Xhold88 run_reg VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__dlygate4sd3_1
Xhold66 uart_curr_state\[2\] VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__dlygate4sd3_1
Xhold77 UART1.RX_dataOut\[0\] VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__buf_1
Xhold55 uart_curr_state\[3\] VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_53_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_8 net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2952_ CPU1.curr_state\[1\] _2059_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__and2_1
XFILLER_0_29_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4553_ clknet_leaf_22_clk _0330_ VGND VGND VPWR VPWR RAM1.mem\[14\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_2883_ net22 net21 _2084_ _0844_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__and4b_1
X_4484_ clknet_leaf_12_clk _0263_ VGND VGND VPWR VPWR RAM1.mem\[4\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_3504_ _0437_ _1405_ _1401_ VGND VGND VPWR VPWR _1406_ sky130_fd_sc_hd__mux2_1
X_3435_ _1145_ _1353_ _1355_ _0456_ VGND VGND VPWR VPWR _1356_ sky130_fd_sc_hd__a211o_1
X_3366_ RAM1.mem\[9\]\[5\] _2076_ VGND VGND VPWR VPWR _1289_ sky130_fd_sc_hd__or2_1
X_2317_ _2049_ CPU1.reg_a_out\[1\] _2065_ VGND VGND VPWR VPWR _2101_ sky130_fd_sc_hd__and3_2
X_3297_ _1112_ _1222_ VGND VGND VPWR VPWR _1223_ sky130_fd_sc_hd__nand2_1
X_2248_ _2033_ _2040_ VGND VGND VPWR VPWR _2041_ sky130_fd_sc_hd__nor2_2
X_2179_ UART1.UART_TX1.clkCount\[5\] _1973_ _1977_ UART1.UART_TX1.clkCount\[6\] VGND
+ VGND VPWR VPWR _1978_ sky130_fd_sc_hd__a22o_1
XFILLER_0_35_204 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput23 net23 VGND VGND VPWR VPWR cmd_byte[2] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_43_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput34 net34 VGND VGND VPWR VPWR data_byte[5] sky130_fd_sc_hd__buf_2
Xoutput45 net45 VGND VGND VPWR VPWR tx_reg[6] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3220_ _1128_ _1143_ _1147_ _1132_ VGND VGND VPWR VPWR _1148_ sky130_fd_sc_hd__a211o_1
X_3151_ _1029_ _1084_ _1085_ _1088_ VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__o211a_1
X_3082_ _1021_ _1022_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__nor2_1
XFILLER_0_27_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2935_ CPU1.instr_reg_out\[6\] _0840_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__nor2_4
XFILLER_0_91_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3984_ _1705_ _1726_ VGND VGND VPWR VPWR _1742_ sky130_fd_sc_hd__and2_1
X_2866_ _0824_ _0825_ _0837_ _0831_ net63 VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__a32o_1
X_2797_ _0615_ _0786_ VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__or2_1
X_4605_ clknet_leaf_2_clk _0382_ VGND VGND VPWR VPWR UART1.UART_TX1.packet\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4536_ clknet_leaf_0_clk _0313_ VGND VGND VPWR VPWR UART1.RX_dataOut\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_25_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4467_ clknet_leaf_6_clk _0246_ VGND VGND VPWR VPWR CPU1.RF1.rf\[0\]\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3349_ RAM1.mem\[7\]\[4\] _2074_ VGND VGND VPWR VPWR _1273_ sky130_fd_sc_hd__or2_1
X_3418_ _1154_ _1338_ VGND VGND VPWR VPWR _1339_ sky130_fd_sc_hd__or2_1
XFILLER_0_7_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4398_ clknet_leaf_20_clk _0177_ VGND VGND VPWR VPWR RAM1.mem\[9\]\[6\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_90_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2720_ RAM1.mem\[20\]\[4\] RAM1.mem\[21\]\[4\] RAM1.mem\[22\]\[4\] RAM1.mem\[23\]\[4\]
+ _0495_ _0578_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__mux4_1
X_2651_ _1928_ _0574_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__nand2_1
X_2582_ _0578_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__buf_4
XFILLER_0_22_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4321_ clknet_leaf_5_clk _0109_ VGND VGND VPWR VPWR CPU1.RF1.rf\[3\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3203_ _0515_ VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__clkbuf_4
X_4183_ _1873_ _1892_ _1893_ _1874_ _1894_ VGND VGND VPWR VPWR _1895_ sky130_fd_sc_hd__o32a_1
XFILLER_0_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4252_ clknet_leaf_21_clk _0047_ VGND VGND VPWR VPWR RAM1.mem\[11\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_3134_ _0915_ _1007_ _1072_ _0921_ VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__a22o_1
X_3065_ CPU1.reg_a_out\[6\] _0903_ _0905_ CPU1.PC1.pc_out\[6\] VGND VGND VPWR VPWR
+ _1007_ sky130_fd_sc_hd__a22o_2
XFILLER_0_54_51 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2918_ net151 _0847_ _0872_ _0874_ _0623_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__o221a_1
XFILLER_0_70_50 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3967_ _2005_ _1728_ _1720_ VGND VGND VPWR VPWR _1729_ sky130_fd_sc_hd__a21bo_1
X_3898_ RAM1.mem\[15\]\[3\] _0473_ _1669_ VGND VGND VPWR VPWR _1678_ sky130_fd_sc_hd__mux2_1
X_2849_ _2041_ _2051_ net50 CPU1.curr_state\[1\] VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__and4b_4
X_4519_ clknet_leaf_16_clk _0296_ VGND VGND VPWR VPWR RAM1.mem\[16\]\[5\] sky130_fd_sc_hd__dfxtp_1
XTAP_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_21_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_21_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_12_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_12_clk sky130_fd_sc_hd__clkbuf_16
X_3821_ RAM1.mem\[6\]\[5\] _0401_ _1611_ VGND VGND VPWR VPWR _1624_ sky130_fd_sc_hd__mux2_1
X_3752_ _0419_ _1573_ _1575_ VGND VGND VPWR VPWR _1576_ sky130_fd_sc_hd__mux2_1
XFILLER_0_86_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3683_ RAM1.mem\[2\]\[0\] _0455_ _1530_ VGND VGND VPWR VPWR _1531_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2565_ net118 _1932_ _0565_ _0557_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__o211a_1
X_2634_ _0580_ _0624_ _0625_ _0629_ _2093_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__a311o_1
X_4304_ clknet_leaf_0_clk _0001_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__dfxtp_1
X_2703_ RAM1.mem\[10\]\[4\] _0581_ _0587_ RAM1.mem\[11\]\[4\] _0584_ VGND VGND VPWR
+ VPWR _0696_ sky130_fd_sc_hd__a221o_1
X_2496_ _0419_ _0520_ _0524_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__mux2_1
X_4235_ clknet_leaf_10_clk _0030_ VGND VGND VPWR VPWR RAM1.mem\[0\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3117_ net156 _0941_ _1056_ _0569_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__o211a_1
X_4166_ UART1.UART_TX1.clkCount\[2\] UART1.UART_TX1.clkCount\[1\] UART1.UART_TX1.clkCount\[0\]
+ VGND VGND VPWR VPWR _1881_ sky130_fd_sc_hd__and3_1
XFILLER_0_81_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_254 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3048_ CPU1.PC1.pc_out\[2\] _0941_ _0990_ _0569_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__o211a_1
X_4097_ _2098_ _1671_ VGND VGND VPWR VPWR _1828_ sky130_fd_sc_hd__nor2_4
XFILLER_0_92_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2281_ _2049_ CPU1.reg_a_out\[0\] _2065_ VGND VGND VPWR VPWR _2066_ sky130_fd_sc_hd__and3_2
X_4020_ RAM1.mem\[14\]\[7\] _0413_ _1751_ VGND VGND VPWR VPWR _1768_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_1_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_1_clk sky130_fd_sc_hd__clkbuf_16
X_2350_ _0403_ _0405_ _2099_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3735_ RAM1.mem\[3\]\[4\] _0395_ _1552_ VGND VGND VPWR VPWR _1563_ sky130_fd_sc_hd__mux2_1
X_3804_ RAM1.mem\[6\]\[0\] _2066_ _1611_ VGND VGND VPWR VPWR _1612_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_195 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3666_ RAM1.mem\[23\]\[3\] _0473_ _1511_ VGND VGND VPWR VPWR _1519_ sky130_fd_sc_hd__mux2_1
XFILLER_0_62_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2548_ net18 _1944_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__or2_1
X_2617_ _0611_ _0613_ _0579_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__mux2_1
X_3597_ _1470_ _0411_ _1458_ VGND VGND VPWR VPWR _1471_ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4218_ net138 net46 _1989_ VGND VGND VPWR VPWR _1918_ sky130_fd_sc_hd__mux2_1
X_2479_ _0510_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__clkbuf_1
X_4149_ net170 _1866_ _1867_ VGND VGND VPWR VPWR _1868_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_73_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_154 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3520_ _1416_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_71_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2402_ _0410_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__clkbuf_4
X_3382_ _0517_ _1291_ _1295_ _1304_ VGND VGND VPWR VPWR _1305_ sky130_fd_sc_hd__a31o_1
X_3451_ _2062_ _1222_ VGND VGND VPWR VPWR _1369_ sky130_fd_sc_hd__nand2_1
X_2333_ _0390_ RAM1.mem\[8\]\[3\] _2081_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__mux2_1
X_2264_ _2050_ _2044_ _2045_ _1946_ _2029_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__o311a_1
X_4003_ _2105_ _1756_ _1754_ VGND VGND VPWR VPWR _1757_ sky130_fd_sc_hd__mux2_1
X_2195_ UART1.UART_RX1.clkCount\[2\] _1967_ _1968_ UART1.UART_RX1.clkCount\[1\] _1991_
+ VGND VGND VPWR VPWR _1992_ sky130_fd_sc_hd__a221o_1
XFILLER_0_47_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3718_ _0837_ _1550_ _1551_ net98 VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__a22o_1
XFILLER_0_62_227 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3649_ RAM1.mem\[19\]\[6\] _0482_ _1493_ VGND VGND VPWR VPWR _1507_ sky130_fd_sc_hd__mux2_1
Xhold34 CPU1.RF1.rf\[0\]\[0\] VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__dlygate4sd3_1
Xhold45 CPU1.RF1.rf\[0\]\[6\] VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__dlygate4sd3_1
Xhold12 CPU1.RF1.rf\[0\]\[4\] VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__dlygate4sd3_1
Xhold56 CPU1.reg_b_out\[5\] VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__dlygate4sd3_1
Xhold23 CPU1.mdr_out\[2\] VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__dlygate4sd3_1
Xhold78 UART1.UART_RX1.dataOut\[2\] VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__dlygate4sd3_1
Xhold67 UART1.RX_dataOut\[5\] VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__buf_1
Xhold89 UART1.RX_dataOut\[2\] VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__buf_1
XFILLER_0_53_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_9 net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_83_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2951_ CPU1.reg_b_out\[1\] _2051_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__or2_1
XFILLER_0_29_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4483_ clknet_leaf_12_clk _0262_ VGND VGND VPWR VPWR RAM1.mem\[4\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_3503_ _2108_ RAM1.mem\[21\]\[2\] _1398_ VGND VGND VPWR VPWR _1405_ sky130_fd_sc_hd__mux2_1
X_4552_ clknet_leaf_3_clk _0329_ VGND VGND VPWR VPWR RAM1.mem\[14\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_2882_ net25 _1941_ _1939_ net26 VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__and4b_1
XFILLER_0_32_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3434_ RAM1.mem\[0\]\[7\] _1157_ _2077_ _1354_ VGND VGND VPWR VPWR _1355_ sky130_fd_sc_hd__o211a_1
X_3296_ _0516_ _1199_ _1203_ _1221_ VGND VGND VPWR VPWR _1222_ sky130_fd_sc_hd__o31ai_4
X_2316_ _2100_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__clkbuf_1
X_3365_ RAM1.mem\[10\]\[5\] RAM1.mem\[11\]\[5\] _1135_ VGND VGND VPWR VPWR _1288_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_67_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2247_ CPU1.instr_reg_out\[1\] _2031_ VGND VGND VPWR VPWR _2040_ sky130_fd_sc_hd__nand2_2
X_2178_ _1956_ _1976_ VGND VGND VPWR VPWR _1977_ sky130_fd_sc_hd__and2_1
XFILLER_0_35_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput35 net35 VGND VGND VPWR VPWR data_byte[6] sky130_fd_sc_hd__clkbuf_4
Xoutput13 net13 VGND VGND VPWR VPWR addr_byte[0] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_43_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput24 net24 VGND VGND VPWR VPWR cmd_byte[3] sky130_fd_sc_hd__clkbuf_4
Xoutput46 net46 VGND VGND VPWR VPWR tx_reg[7] sky130_fd_sc_hd__clkbuf_4
XPHY_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3150_ _0901_ _1048_ _1087_ VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__a21o_1
X_3081_ _1000_ _0999_ _1020_ VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_76_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2934_ CPU1.reg_a_out\[7\] _0847_ _0885_ _0887_ _0879_ VGND VGND VPWR VPWR _0129_
+ sky130_fd_sc_hd__o221a_1
X_2865_ CPU1.mdr_out\[6\] _0827_ _0829_ CPU1.alu_reg_out\[6\] VGND VGND VPWR VPWR
+ _0837_ sky130_fd_sc_hd__a22o_2
X_3983_ _2004_ _1694_ _1688_ UART1.UART_RX1.index\[2\] VGND VGND VPWR VPWR _1741_
+ sky130_fd_sc_hd__or4bb_1
X_4466_ clknet_leaf_6_clk _0245_ VGND VGND VPWR VPWR CPU1.RF1.rf\[0\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_2796_ _0784_ _0785_ _0578_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__mux2_1
XFILLER_0_40_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4604_ clknet_leaf_2_clk _0381_ VGND VGND VPWR VPWR UART1.UART_TX1.packet\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4535_ clknet_leaf_1_clk _0312_ VGND VGND VPWR VPWR UART1.RX_dataOut\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3348_ RAM1.mem\[4\]\[4\] RAM1.mem\[5\]\[4\] _1155_ VGND VGND VPWR VPWR _1272_ sky130_fd_sc_hd__mux2_1
XTAP_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3417_ RAM1.mem\[22\]\[7\] RAM1.mem\[23\]\[7\] _1137_ VGND VGND VPWR VPWR _1338_
+ sky130_fd_sc_hd__mux2_1
X_4397_ clknet_leaf_16_clk _0176_ VGND VGND VPWR VPWR RAM1.mem\[9\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_3279_ RAM1.mem\[9\]\[2\] _2076_ VGND VGND VPWR VPWR _1205_ sky130_fd_sc_hd__or2_1
XFILLER_0_90_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_151 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_81_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4320_ clknet_leaf_5_clk _0108_ VGND VGND VPWR VPWR CPU1.RF1.rf\[3\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_2581_ _0577_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__buf_4
X_2650_ _0521_ _0630_ _0637_ _0645_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__a31o_1
XFILLER_0_1_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3133_ _1007_ _1058_ VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__nand2_1
X_3202_ _1128_ _1129_ VGND VGND VPWR VPWR _1130_ sky130_fd_sc_hd__or2_1
X_4182_ net162 VGND VGND VPWR VPWR _1894_ sky130_fd_sc_hd__inv_2
X_4251_ clknet_leaf_20_clk _0046_ VGND VGND VPWR VPWR RAM1.mem\[11\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_3064_ _0956_ _1005_ VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__nand2_1
XFILLER_0_54_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2848_ _0825_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__buf_2
XFILLER_0_92_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2917_ _0852_ _2056_ _0873_ _0857_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__a31o_1
XFILLER_0_72_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3897_ _1677_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__clkbuf_1
X_3966_ UART1.UART_RX1.dataOut\[1\] _1724_ _1725_ _1727_ VGND VGND VPWR VPWR _1728_
+ sky130_fd_sc_hd__a22o_1
X_4449_ clknet_leaf_13_clk _0228_ VGND VGND VPWR VPWR RAM1.mem\[23\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_2779_ RAM1.mem\[12\]\[7\] RAM1.mem\[13\]\[7\] _0593_ VGND VGND VPWR VPWR _0769_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4518_ clknet_leaf_18_clk _0295_ VGND VGND VPWR VPWR RAM1.mem\[16\]\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3820_ _1623_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__clkbuf_1
X_3751_ _1574_ VGND VGND VPWR VPWR _1575_ sky130_fd_sc_hd__clkbuf_4
X_3682_ _1529_ _0461_ VGND VGND VPWR VPWR _1530_ sky130_fd_sc_hd__nor2_4
X_2702_ net42 _0575_ _0695_ _0569_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__o211a_1
XFILLER_0_6_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2495_ _0523_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_49_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2564_ net33 _0560_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__or2_1
X_4303_ clknet_leaf_0_clk _0000_ VGND VGND VPWR VPWR _4303_/Q sky130_fd_sc_hd__dfxtp_2
X_2633_ _0591_ _0626_ _0628_ _0600_ VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__o211a_1
X_3116_ net18 _0936_ _1055_ _0905_ _0937_ VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__a221o_1
X_4234_ clknet_leaf_16_clk _0029_ VGND VGND VPWR VPWR RAM1.mem\[8\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_4096_ _2067_ RAM1.mem\[12\]\[0\] _1826_ VGND VGND VPWR VPWR _1827_ sky130_fd_sc_hd__mux2_1
X_4165_ UART1.UART_TX1.clkCount\[2\] _1876_ VGND VGND VPWR VPWR _1880_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_266 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3047_ net15 _0936_ _0989_ _0905_ _0937_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__a221o_1
X_3949_ net135 VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2280_ net51 VGND VGND VPWR VPWR _2065_ sky130_fd_sc_hd__buf_2
X_3803_ _0461_ _1610_ VGND VGND VPWR VPWR _1611_ sky130_fd_sc_hd__nor2_4
X_3734_ _1562_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__clkbuf_1
X_3665_ _1518_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_144 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2616_ RAM1.mem\[18\]\[0\] RAM1.mem\[19\]\[0\] _0612_ VGND VGND VPWR VPWR _0613_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_100_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4217_ _1917_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__clkbuf_1
X_2547_ net118 _0550_ _0555_ _0545_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__o211a_1
X_3596_ RAM1.mem\[18\]\[6\] _0482_ _1455_ VGND VGND VPWR VPWR _1470_ sky130_fd_sc_hd__mux2_1
X_2478_ _0509_ _0405_ _0499_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__mux2_1
X_4079_ CPU1.reg_b_out\[4\] _0846_ _1811_ _1813_ _0879_ VGND VGND VPWR VPWR _0348_
+ sky130_fd_sc_hd__o221a_1
X_4148_ _1844_ UART1.UART_TX1.index\[1\] _1859_ _1861_ VGND VGND VPWR VPWR _1867_
+ sky130_fd_sc_hd__and4_1
XFILLER_0_65_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2401_ _0448_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__clkbuf_1
X_3381_ _1149_ _1299_ _1303_ _1162_ VGND VGND VPWR VPWR _1304_ sky130_fd_sc_hd__a31o_1
X_3450_ _1365_ _2049_ _1366_ _1368_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__o211a_1
X_2332_ _0389_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__buf_4
X_4002_ RAM1.mem\[14\]\[1\] _2101_ _1751_ VGND VGND VPWR VPWR _1756_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_64 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2263_ _2047_ _2048_ _2052_ _2053_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__a211o_1
X_2194_ net1 UART1.UART_RX1.clkCount\[0\] _1968_ UART1.UART_RX1.clkCount\[1\] VGND
+ VGND VPWR VPWR _1991_ sky130_fd_sc_hd__o22a_1
XFILLER_0_62_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3717_ _0836_ _1550_ _1551_ net94 VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__a22o_1
XFILLER_0_70_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3579_ _1456_ _2088_ _1458_ VGND VGND VPWR VPWR _1459_ sky130_fd_sc_hd__mux2_1
X_3648_ _1506_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__clkbuf_1
Xhold35 CPU1.RF1.rf\[2\]\[5\] VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__dlygate4sd3_1
Xhold46 CPU1.RF1.rf\[0\]\[1\] VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 CPU1.RF1.rf\[2\]\[1\] VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__dlygate4sd3_1
Xhold13 CPU1.RF1.rf\[3\]\[3\] VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__dlygate4sd3_1
Xhold79 UART1.UART_TX1.clkCount\[9\] VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__dlygate4sd3_1
Xhold57 UART1.UART_RX1.state\[0\] VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__dlygate4sd3_1
Xhold68 _1716_ VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2881_ _0838_ _0842_ _0843_ net106 VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__a22o_1
XFILLER_0_88_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2950_ CPU1.instr_reg_out\[5\] _2036_ _2041_ CPU1.instr_reg_out\[4\] _2044_ VGND
+ VGND VPWR VPWR _0895_ sky130_fd_sc_hd__a221o_1
XFILLER_0_32_66 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_32_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4482_ clknet_leaf_12_clk _0261_ VGND VGND VPWR VPWR RAM1.mem\[4\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_3502_ _1404_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__clkbuf_1
X_3433_ RAM1.mem\[1\]\[7\] _1158_ VGND VGND VPWR VPWR _1354_ sky130_fd_sc_hd__or2_1
X_4551_ clknet_leaf_2_clk _0328_ VGND VGND VPWR VPWR RAM1.mem\[14\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2246_ CPU1.instr_reg_out\[1\] _2038_ VGND VGND VPWR VPWR _2039_ sky130_fd_sc_hd__and2_2
XFILLER_0_57_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3295_ _0517_ _1207_ _1211_ _1220_ VGND VGND VPWR VPWR _1221_ sky130_fd_sc_hd__a31o_1
X_3364_ _1117_ _1284_ _1286_ _1132_ VGND VGND VPWR VPWR _1287_ sky130_fd_sc_hd__o211a_1
X_2315_ _2082_ _2088_ _2099_ VGND VGND VPWR VPWR _2100_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2177_ net7 _1955_ VGND VGND VPWR VPWR _1976_ sky130_fd_sc_hd__nand2_1
XFILLER_0_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_43_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput25 net25 VGND VGND VPWR VPWR cmd_byte[4] sky130_fd_sc_hd__clkbuf_4
Xoutput47 net47 VGND VGND VPWR VPWR uart_tx sky130_fd_sc_hd__clkbuf_4
Xoutput36 net36 VGND VGND VPWR VPWR data_byte[7] sky130_fd_sc_hd__buf_2
Xoutput14 net14 VGND VGND VPWR VPWR addr_byte[1] sky130_fd_sc_hd__clkbuf_4
XPHY_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3080_ _1000_ _0999_ _1020_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__and3_1
XFILLER_0_76_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3982_ _1738_ _1740_ _1940_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__o21a_1
X_2864_ _0824_ _0825_ _0836_ _0831_ net83 VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__a32o_1
X_2933_ _0852_ _2056_ _0886_ _0857_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__a31o_1
X_2795_ RAM1.mem\[22\]\[7\] RAM1.mem\[23\]\[7\] _0495_ VGND VGND VPWR VPWR _0785_
+ sky130_fd_sc_hd__mux2_1
X_4603_ clknet_leaf_2_clk _0380_ VGND VGND VPWR VPWR UART1.UART_TX1.packet\[5\] sky130_fd_sc_hd__dfxtp_1
X_4465_ clknet_leaf_6_clk _0244_ VGND VGND VPWR VPWR CPU1.RF1.rf\[0\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_3416_ RAM1.mem\[20\]\[7\] RAM1.mem\[21\]\[7\] _1138_ VGND VGND VPWR VPWR _1337_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_40_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4396_ clknet_leaf_16_clk _0175_ VGND VGND VPWR VPWR RAM1.mem\[9\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_4534_ clknet_leaf_25_clk _0311_ VGND VGND VPWR VPWR UART1.UART_RX1.index\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_25_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3347_ _1145_ _1268_ _1270_ _0456_ VGND VGND VPWR VPWR _1271_ sky130_fd_sc_hd__a211o_1
XTAP_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2229_ _2004_ _2002_ UART1.UART_RX1.state\[1\] VGND VGND VPWR VPWR _2024_ sky130_fd_sc_hd__a21bo_1
X_3278_ RAM1.mem\[10\]\[2\] RAM1.mem\[11\]\[2\] _1135_ VGND VGND VPWR VPWR _1204_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_67_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2580_ net14 uart_curr_state\[1\] _2090_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__and3_2
X_4250_ clknet_leaf_21_clk _0045_ VGND VGND VPWR VPWR RAM1.mem\[10\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_22_220 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3132_ _0901_ _1069_ _1070_ _0956_ VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__o211a_1
X_3063_ _0955_ _1004_ _0953_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__mux2_1
X_4181_ UART1.UART_TX1.clkCount\[4\] _1885_ UART1.UART_TX1.clkCount\[5\] VGND VGND
+ VPWR VPWR _1893_ sky130_fd_sc_hd__a21oi_1
X_3201_ RAM1.mem\[18\]\[0\] RAM1.mem\[19\]\[0\] _1118_ VGND VGND VPWR VPWR _1129_
+ sky130_fd_sc_hd__mux2_1
X_3965_ _2004_ _1726_ VGND VGND VPWR VPWR _1727_ sky130_fd_sc_hd__nor2_1
XFILLER_0_9_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2916_ CPU1.RF1.rf\[3\]\[4\] CPU1.RF1.rf\[2\]\[4\] _0848_ VGND VGND VPWR VPWR _0873_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_85_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold110 CPU1.instr_reg_out\[6\] VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_70_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2778_ RAM1.mem\[14\]\[7\] _0586_ _0583_ RAM1.mem\[15\]\[7\] _0605_ VGND VGND VPWR
+ VPWR _0768_ sky130_fd_sc_hd__a221o_1
X_2847_ CPU1.curr_state\[4\] _2046_ _1939_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__o21a_4
X_3896_ _1676_ _2110_ _1672_ VGND VGND VPWR VPWR _1677_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4448_ clknet_leaf_13_clk _0227_ VGND VGND VPWR VPWR RAM1.mem\[23\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_4379_ clknet_leaf_3_clk _0158_ VGND VGND VPWR VPWR CPU1.mdr_out\[3\] sky130_fd_sc_hd__dfxtp_1
X_4517_ clknet_leaf_17_clk _0294_ VGND VGND VPWR VPWR RAM1.mem\[16\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_13_264 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_234 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_175 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_86_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3681_ _0456_ _0421_ VGND VGND VPWR VPWR _1529_ sky130_fd_sc_hd__or2_2
X_3750_ _0425_ _2098_ _0615_ _0430_ VGND VGND VPWR VPWR _1574_ sky130_fd_sc_hd__or4_1
XFILLER_0_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2701_ CPU1.PC1.pc_out\[3\] _1926_ _0694_ _1923_ _0647_ VGND VGND VPWR VPWR _0695_
+ sky130_fd_sc_hd__a221o_1
X_2632_ _0584_ _0627_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__or2_1
X_2494_ _0464_ _0522_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__or2_1
XFILLER_0_49_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4302_ clknet_leaf_2_clk _0093_ VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__dfxtp_1
X_4233_ clknet_leaf_20_clk _0028_ VGND VGND VPWR VPWR RAM1.mem\[8\]\[6\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_10_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2563_ UART1.RX_dataOut\[3\] _1932_ _0564_ _0557_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__o211a_1
XFILLER_0_77_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3115_ _1046_ _1047_ _1050_ _1054_ VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__a211o_1
X_3046_ _0988_ VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__inv_2
X_4095_ _2080_ _1770_ VGND VGND VPWR VPWR _1826_ sky130_fd_sc_hd__nand2_4
XFILLER_0_4_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4164_ _2058_ _1879_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3948_ UART1.RX_dataOut\[4\] net134 _1710_ VGND VGND VPWR VPWR _1715_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3879_ _1664_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_101_16 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3802_ _1190_ _0421_ VGND VGND VPWR VPWR _1610_ sky130_fd_sc_hd__or2_2
XFILLER_0_51_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3733_ _0440_ _1561_ _1555_ VGND VGND VPWR VPWR _1562_ sky130_fd_sc_hd__mux2_1
X_3664_ _1517_ _2110_ _1513_ VGND VGND VPWR VPWR _1518_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_156 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3595_ _1469_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__clkbuf_1
X_2615_ _0592_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_48_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4216_ net125 net45 _1989_ VGND VGND VPWR VPWR _1917_ sky130_fd_sc_hd__mux2_1
X_2546_ net17 _1944_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__or2_1
X_2477_ RAM1.mem\[11\]\[5\] _0479_ _0490_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__mux2_1
X_4147_ net161 _1861_ _1866_ _0623_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__o211a_1
X_4078_ _1372_ _2055_ _1812_ _0856_ VGND VGND VPWR VPWR _1813_ sky130_fd_sc_hd__a31o_1
X_3029_ CPU1.reg_a_out\[5\] _0903_ _0905_ CPU1.PC1.pc_out\[5\] VGND VGND VPWR VPWR
+ _0972_ sky130_fd_sc_hd__a22o_2
XFILLER_0_65_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2400_ _0446_ _0447_ _0432_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3380_ _1154_ _1300_ _1302_ _1190_ VGND VGND VPWR VPWR _1303_ sky130_fd_sc_hd__a211o_1
X_2331_ _2049_ CPU1.reg_a_out\[3\] _2065_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__and3_2
X_2262_ _2032_ _2033_ _2029_ _2040_ _1951_ VGND VGND VPWR VPWR _2053_ sky130_fd_sc_hd__a41o_1
X_4001_ _1755_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2193_ _1990_ UART1.UART_TX1.state\[0\] net55 _1952_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__a211o_1
X_3716_ _0835_ _1550_ _1551_ net65 VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__a22o_1
X_2529_ net25 _0540_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__or2_1
XFILLER_0_30_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3647_ _1505_ _0405_ _1495_ VGND VGND VPWR VPWR _1506_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3578_ _0464_ _1457_ VGND VGND VPWR VPWR _1458_ sky130_fd_sc_hd__nor2_4
Xhold36 CPU1.RF1.rf\[0\]\[2\] VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__dlygate4sd3_1
Xhold47 CPU1.RF1.rf\[1\]\[2\] VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__dlygate4sd3_1
Xhold14 CPU1.RF1.rf\[0\]\[7\] VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 CPU1.mdr_out\[3\] VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__dlygate4sd3_1
Xhold69 UART1.UART_TX1.packet\[2\] VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__dlygate4sd3_1
Xhold58 _0012_ VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_21_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_88_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2880_ _0837_ _0842_ _0843_ net101 VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__a22o_1
XFILLER_0_37_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4481_ clknet_leaf_12_clk _0260_ VGND VGND VPWR VPWR RAM1.mem\[4\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_3501_ _0434_ _1403_ _1401_ VGND VGND VPWR VPWR _1404_ sky130_fd_sc_hd__mux2_1
X_3432_ RAM1.mem\[2\]\[7\] RAM1.mem\[3\]\[7\] _1155_ VGND VGND VPWR VPWR _1353_ sky130_fd_sc_hd__mux2_1
X_3363_ _1121_ _1285_ VGND VGND VPWR VPWR _1286_ sky130_fd_sc_hd__or2_1
X_4550_ clknet_leaf_25_clk _0327_ VGND VGND VPWR VPWR UART1.UART_RX1.dataOut\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3294_ _1149_ _1215_ _1219_ _1162_ VGND VGND VPWR VPWR _1220_ sky130_fd_sc_hd__a31o_1
X_2245_ _2032_ _2033_ _2031_ _2037_ VGND VGND VPWR VPWR _2038_ sky130_fd_sc_hd__nor4_1
X_2314_ _2094_ _2098_ VGND VGND VPWR VPWR _2099_ sky130_fd_sc_hd__nor2_4
X_2176_ UART1.UART_TX1.clkCount\[4\] _1961_ _1965_ _1971_ _1974_ VGND VGND VPWR VPWR
+ _1975_ sky130_fd_sc_hd__o221a_1
Xoutput26 net26 VGND VGND VPWR VPWR cmd_byte[5] sky130_fd_sc_hd__clkbuf_4
Xoutput15 net15 VGND VGND VPWR VPWR addr_byte[2] sky130_fd_sc_hd__clkbuf_4
Xoutput37 net37 VGND VGND VPWR VPWR done sky130_fd_sc_hd__clkbuf_4
XFILLER_0_85_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2932_ CPU1.RF1.rf\[3\]\[7\] CPU1.RF1.rf\[2\]\[7\] _0848_ VGND VGND VPWR VPWR _0886_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3981_ _1695_ _1719_ _1727_ _1739_ VGND VGND VPWR VPWR _1740_ sky130_fd_sc_hd__and4b_1
XFILLER_0_84_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2863_ CPU1.mdr_out\[5\] _0827_ _0829_ CPU1.alu_reg_out\[5\] VGND VGND VPWR VPWR
+ _0836_ sky130_fd_sc_hd__a22o_2
X_2794_ RAM1.mem\[20\]\[7\] RAM1.mem\[21\]\[7\] _0495_ VGND VGND VPWR VPWR _0784_
+ sky130_fd_sc_hd__mux2_1
X_4602_ clknet_leaf_22_clk _0379_ VGND VGND VPWR VPWR UART1.UART_TX1.packet\[4\] sky130_fd_sc_hd__dfxtp_1
X_4533_ clknet_leaf_25_clk _0310_ VGND VGND VPWR VPWR UART1.UART_RX1.index\[2\] sky130_fd_sc_hd__dfxtp_2
X_4464_ clknet_leaf_6_clk _0243_ VGND VGND VPWR VPWR CPU1.RF1.rf\[0\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_3346_ RAM1.mem\[0\]\[4\] _1157_ _2078_ _1269_ VGND VGND VPWR VPWR _1270_ sky130_fd_sc_hd__o211a_1
XTAP_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3415_ net79 _1113_ _1336_ _1308_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__o211a_1
XFILLER_0_68_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4395_ clknet_leaf_20_clk _0174_ VGND VGND VPWR VPWR RAM1.mem\[9\]\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3277_ _1117_ _1200_ _1202_ _1132_ VGND VGND VPWR VPWR _1203_ sky130_fd_sc_hd__o211a_1
X_2228_ _2008_ _2023_ _1952_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__a21oi_1
X_2159_ net10 _1957_ VGND VGND VPWR VPWR _1958_ sky130_fd_sc_hd__nand2_2
XFILLER_0_75_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_24_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_24_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_13_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3200_ _2078_ VGND VGND VPWR VPWR _1128_ sky130_fd_sc_hd__clkbuf_4
X_4180_ UART1.UART_TX1.clkCount\[5\] UART1.UART_TX1.clkCount\[4\] _1885_ VGND VGND
+ VPWR VPWR _1892_ sky130_fd_sc_hd__and3_1
XFILLER_0_22_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3131_ _0953_ _1024_ VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__or2_1
X_3062_ net49 _0906_ _0960_ VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_54_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2915_ CPU1.RF1.rf\[1\]\[4\] _0849_ _0871_ _0853_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__o211a_1
Xclkbuf_leaf_15_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_15_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3895_ RAM1.mem\[15\]\[2\] _0470_ _1669_ VGND VGND VPWR VPWR _1676_ sky130_fd_sc_hd__mux2_1
X_3964_ UART1.UART_RX1.index\[2\] _1695_ VGND VGND VPWR VPWR _1726_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_9_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2846_ _0823_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__buf_2
Xhold100 CPU1.reg_a_out\[6\] VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_78_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4516_ clknet_leaf_18_clk _0293_ VGND VGND VPWR VPWR RAM1.mem\[16\]\[2\] sky130_fd_sc_hd__dfxtp_1
Xhold111 UART1.UART_RX1.index\[3\] VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2777_ RAM1.mem\[10\]\[7\] _0582_ _0497_ RAM1.mem\[11\]\[7\] _0428_ VGND VGND VPWR
+ VPWR _0767_ sky130_fd_sc_hd__a221o_1
X_3329_ RAM1.mem\[22\]\[4\] RAM1.mem\[23\]\[4\] _1137_ VGND VGND VPWR VPWR _1253_
+ sky130_fd_sc_hd__mux2_1
X_4378_ clknet_leaf_8_clk _0157_ VGND VGND VPWR VPWR CPU1.mdr_out\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4447_ clknet_leaf_18_clk _0226_ VGND VGND VPWR VPWR RAM1.mem\[19\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_95_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_184 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_86_213 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3680_ _1528_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__clkbuf_1
X_2700_ _0521_ _0680_ _0687_ _0693_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__a31o_1
X_2631_ RAM1.mem\[8\]\[1\] RAM1.mem\[9\]\[1\] _0592_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__mux2_1
X_2562_ net32 _0560_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__or2_1
Xclkbuf_leaf_4_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_4_clk sky130_fd_sc_hd__clkbuf_16
X_2493_ _0521_ net16 net15 VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__or3b_4
X_4301_ clknet_leaf_2_clk _0092_ VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__dfxtp_2
X_4232_ clknet_leaf_17_clk _0027_ VGND VGND VPWR VPWR RAM1.mem\[8\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_4163_ _1873_ _1876_ _1877_ _1874_ _1878_ VGND VGND VPWR VPWR _1879_ sky130_fd_sc_hd__o32a_1
X_4094_ net97 _0846_ _1823_ _1825_ _1366_ VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__o221a_1
X_3114_ _0915_ _0972_ _1052_ _0894_ _1053_ VGND VGND VPWR VPWR _1054_ sky130_fd_sc_hd__a221o_1
XFILLER_0_65_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3045_ _0977_ _0987_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__nor2_1
X_3878_ _1663_ _0410_ _1651_ VGND VGND VPWR VPWR _1664_ sky130_fd_sc_hd__mux2_1
X_3947_ _1714_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2829_ UART1.UART_RX1.clkCount\[4\] UART1.UART_RX1.clkCount\[3\] _0804_ UART1.UART_RX1.clkCount\[5\]
+ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__a31o_1
XTAP_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3732_ RAM1.mem\[3\]\[3\] _0389_ _1552_ VGND VGND VPWR VPWR _1561_ sky130_fd_sc_hd__mux2_1
X_3801_ _1609_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_67_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3663_ RAM1.mem\[23\]\[2\] _0470_ _1511_ VGND VGND VPWR VPWR _1517_ sky130_fd_sc_hd__mux2_1
X_2545_ UART1.RX_dataOut\[3\] _0550_ _0554_ _0545_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__o211a_1
XFILLER_0_42_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2614_ RAM1.mem\[16\]\[0\] RAM1.mem\[17\]\[0\] _0496_ VGND VGND VPWR VPWR _0611_
+ sky130_fd_sc_hd__mux2_1
X_3594_ _1468_ _0405_ _1458_ VGND VGND VPWR VPWR _1469_ sky130_fd_sc_hd__mux2_1
X_4215_ _1916_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__clkbuf_1
X_2476_ _0508_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__clkbuf_1
X_4146_ UART1.UART_TX1.index\[1\] _1861_ _1859_ _1858_ VGND VGND VPWR VPWR _1866_
+ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_97_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4077_ CPU1.RF1.rf\[3\]\[4\] CPU1.RF1.rf\[2\]\[4\] _1790_ VGND VGND VPWR VPWR _1812_
+ sky130_fd_sc_hd__mux2_1
X_3028_ _0907_ _0969_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__or2_1
XFILLER_0_18_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2261_ _2050_ _2045_ _2051_ CPU1.curr_state\[1\] VGND VGND VPWR VPWR _2052_ sky130_fd_sc_hd__and4bb_1
X_4000_ _2088_ _1752_ _1754_ VGND VGND VPWR VPWR _1755_ sky130_fd_sc_hd__mux2_1
X_2192_ UART1.TX_en VGND VGND VPWR VPWR _1990_ sky130_fd_sc_hd__inv_2
X_2330_ _0388_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3715_ _0834_ _1550_ _1551_ net82 VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__a22o_1
XFILLER_0_70_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3577_ net16 net15 _0521_ VGND VGND VPWR VPWR _1457_ sky130_fd_sc_hd__or3_4
X_2528_ UART1.RX_dataOut\[3\] _1937_ _0544_ _0545_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__o211a_1
X_3646_ RAM1.mem\[19\]\[5\] _0479_ _1493_ VGND VGND VPWR VPWR _1505_ sky130_fd_sc_hd__mux2_1
Xhold48 CPU1.RF1.rf\[1\]\[6\] VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__dlygate4sd3_1
Xhold15 CPU1.RF1.rf\[3\]\[0\] VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__dlygate4sd3_1
Xhold26 CPU1.mdr_out\[6\] VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dlygate4sd3_1
Xhold37 CPU1.alu_reg_out\[2\] VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dlygate4sd3_1
X_2459_ _0495_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__clkbuf_4
X_4129_ UART1.UART_TX1.state\[2\] VGND VGND VPWR VPWR _1852_ sky130_fd_sc_hd__inv_2
Xhold59 UART1.UART_RX1.dataOut\[0\] VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_38_238 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3500_ _2102_ RAM1.mem\[21\]\[1\] _1398_ VGND VGND VPWR VPWR _1403_ sky130_fd_sc_hd__mux2_1
X_4480_ clknet_leaf_13_clk _0259_ VGND VGND VPWR VPWR RAM1.mem\[4\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_3431_ _1128_ _1349_ _1351_ _1131_ VGND VGND VPWR VPWR _1352_ sky130_fd_sc_hd__a211o_1
X_2313_ _2097_ VGND VGND VPWR VPWR _2098_ sky130_fd_sc_hd__buf_4
X_3362_ RAM1.mem\[18\]\[5\] RAM1.mem\[19\]\[5\] _1122_ VGND VGND VPWR VPWR _1285_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3293_ _1154_ _1216_ _1218_ _1190_ VGND VGND VPWR VPWR _1219_ sky130_fd_sc_hd__a211o_1
X_2244_ CPU1.curr_state\[5\] VGND VGND VPWR VPWR _2037_ sky130_fd_sc_hd__inv_2
XFILLER_0_57_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2175_ UART1.UART_TX1.clkCount\[5\] _1973_ VGND VGND VPWR VPWR _1974_ sky130_fd_sc_hd__or2_1
XFILLER_0_75_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3629_ _0489_ _1454_ VGND VGND VPWR VPWR _1493_ sky130_fd_sc_hd__nor2_4
Xoutput16 net16 VGND VGND VPWR VPWR addr_byte[3] sky130_fd_sc_hd__clkbuf_4
Xoutput27 net27 VGND VGND VPWR VPWR cmd_byte[6] sky130_fd_sc_hd__clkbuf_4
Xoutput38 net38 VGND VGND VPWR VPWR halt sky130_fd_sc_hd__clkbuf_4
XPHY_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_308 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2931_ CPU1.RF1.rf\[1\]\[7\] _0849_ _0884_ _0853_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__o211a_1
XFILLER_0_84_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XPHY_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3980_ UART1.UART_RX1.state\[1\] UART1.UART_RX1.regIn VGND VGND VPWR VPWR _1739_
+ sky130_fd_sc_hd__and2_1
X_2862_ _0824_ _0825_ _0835_ _0831_ net64 VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__a32o_1
X_4463_ clknet_leaf_9_clk _0242_ VGND VGND VPWR VPWR RAM1.mem\[2\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_2793_ _0781_ _0782_ _0579_ VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__mux2_1
X_4601_ clknet_leaf_22_clk _0378_ VGND VGND VPWR VPWR UART1.UART_TX1.packet\[3\] sky130_fd_sc_hd__dfxtp_1
X_4532_ clknet_leaf_26_clk _0309_ VGND VGND VPWR VPWR UART1.UART_RX1.index\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3345_ RAM1.mem\[1\]\[4\] _1158_ VGND VGND VPWR VPWR _1269_ sky130_fd_sc_hd__or2_1
XTAP_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3414_ _1112_ _1335_ VGND VGND VPWR VPWR _1336_ sky130_fd_sc_hd__nand2_1
XFILLER_0_7_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4394_ clknet_leaf_19_clk _0173_ VGND VGND VPWR VPWR RAM1.mem\[9\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_3276_ _1121_ _1201_ VGND VGND VPWR VPWR _1202_ sky130_fd_sc_hd__or2_1
XTAP_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2227_ _2016_ _2022_ net149 VGND VGND VPWR VPWR _2023_ sky130_fd_sc_hd__o21ai_2
X_2158_ net9 net8 _1956_ VGND VGND VPWR VPWR _1957_ sky130_fd_sc_hd__or3_4
XFILLER_0_23_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_155 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_98_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3130_ _0913_ _1007_ _0973_ VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__o21a_1
X_3061_ _0996_ _0999_ _1002_ VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__o21a_1
XFILLER_0_54_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2914_ CPU1.RF1.rf\[0\]\[4\] _0850_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__or2_1
X_2845_ CPU1.instr_reg_out\[7\] CPU1.instr_reg_out\[6\] _2046_ VGND VGND VPWR VPWR
+ _0823_ sky130_fd_sc_hd__and3_1
XFILLER_0_72_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3963_ _1694_ _1688_ UART1.UART_RX1.regIn VGND VGND VPWR VPWR _1725_ sky130_fd_sc_hd__and3b_1
X_3894_ _1675_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__clkbuf_1
Xhold112 CPU1.reg_a_out\[2\] VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__dlygate4sd3_1
Xhold101 CPU1.reg_a_out\[3\] VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_79_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2776_ _0766_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__clkbuf_1
X_4515_ clknet_leaf_17_clk _0292_ VGND VGND VPWR VPWR RAM1.mem\[16\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_4446_ clknet_leaf_19_clk _0225_ VGND VGND VPWR VPWR RAM1.mem\[19\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_3259_ _1116_ _1183_ _1185_ _0456_ VGND VGND VPWR VPWR _1186_ sky130_fd_sc_hd__a211o_1
X_4377_ clknet_leaf_8_clk _0156_ VGND VGND VPWR VPWR CPU1.mdr_out\[1\] sky130_fd_sc_hd__dfxtp_1
X_3328_ RAM1.mem\[20\]\[4\] RAM1.mem\[21\]\[4\] _1138_ VGND VGND VPWR VPWR _1252_
+ sky130_fd_sc_hd__mux2_1
XTAP_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2492_ net17 _1919_ _2090_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__nand3_4
X_4300_ clknet_leaf_2_clk _0091_ VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_40_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2561_ net142 _1932_ _0563_ _0557_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__o211a_1
X_2630_ RAM1.mem\[12\]\[1\] RAM1.mem\[13\]\[1\] _0612_ VGND VGND VPWR VPWR _0626_
+ sky130_fd_sc_hd__mux2_1
X_4093_ _1372_ _2055_ _1824_ _0856_ VGND VGND VPWR VPWR _1825_ sky130_fd_sc_hd__a31o_1
X_3113_ _0972_ _1040_ _0923_ VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_65_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4231_ clknet_leaf_16_clk _0026_ VGND VGND VPWR VPWR RAM1.mem\[8\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4162_ UART1.UART_TX1.clkCount\[1\] VGND VGND VPWR VPWR _1878_ sky130_fd_sc_hd__inv_2
X_3044_ _0982_ _0983_ _0986_ _0956_ VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_45_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3877_ _0408_ RAM1.mem\[16\]\[6\] _1649_ VGND VGND VPWR VPWR _1663_ sky130_fd_sc_hd__mux2_1
X_2828_ UART1.UART_RX1.clkCount\[5\] UART1.UART_RX1.clkCount\[4\] _0807_ VGND VGND
+ VPWR VPWR _0811_ sky130_fd_sc_hd__and3_1
X_3946_ UART1.RX_dataOut\[3\] net105 _1710_ VGND VGND VPWR VPWR _1714_ sky130_fd_sc_hd__mux2_1
X_2759_ _0427_ _0749_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__or2_1
X_4429_ clknet_leaf_19_clk _0208_ VGND VGND VPWR VPWR RAM1.mem\[18\]\[5\] sky130_fd_sc_hd__dfxtp_1
XTAP_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3731_ _1560_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_82_272 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_74_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3800_ _0452_ _1608_ _1594_ VGND VGND VPWR VPWR _1609_ sky130_fd_sc_hd__mux2_1
X_3662_ _1516_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__clkbuf_1
X_2613_ _0580_ _0603_ _0604_ _0609_ _0426_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__a311o_1
X_2544_ net16 _1944_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__or2_1
XFILLER_0_30_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2475_ _0507_ _0399_ _0499_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__mux2_1
X_3593_ RAM1.mem\[18\]\[5\] _0479_ _1455_ VGND VGND VPWR VPWR _1468_ sky130_fd_sc_hd__mux2_1
X_4076_ CPU1.RF1.rf\[1\]\[4\] _1791_ _1810_ _1794_ VGND VGND VPWR VPWR _1811_ sky130_fd_sc_hd__o211a_1
X_4214_ net129 net44 _1989_ VGND VGND VPWR VPWR _1916_ sky130_fd_sc_hd__mux2_1
X_4145_ _1865_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3027_ _0907_ _0969_ VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__nand2_1
XFILLER_0_73_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3929_ UART1.UART_RX1.state\[1\] _1701_ VGND VGND VPWR VPWR _1702_ sky130_fd_sc_hd__nand2_1
XFILLER_0_64_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2260_ _2042_ _2043_ VGND VGND VPWR VPWR _2051_ sky130_fd_sc_hd__and2_4
X_2191_ _1946_ net133 _1987_ _1989_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__a31o_1
XFILLER_0_62_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3714_ _0833_ _1550_ _1551_ net89 VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__a22o_1
X_3645_ _1504_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold38 CPU1.RF1.rf\[1\]\[4\] VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dlygate4sd3_1
Xhold16 CPU1.alu_reg_out\[3\] VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__dlygate4sd3_1
X_2458_ _0494_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__buf_4
XFILLER_0_53_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2527_ _2063_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__clkbuf_4
Xhold27 UART1.UART_RX1.clkCount\[4\] VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dlygate4sd3_1
X_3576_ RAM1.mem\[18\]\[0\] _0455_ _1455_ VGND VGND VPWR VPWR _1456_ sky130_fd_sc_hd__mux2_1
Xhold49 CPU1.RF1.rf\[1\]\[3\] VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__dlygate4sd3_1
X_2389_ _0439_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__clkbuf_1
X_4059_ CPU1.reg_b_out\[0\] _0847_ _1795_ _1797_ _0879_ VGND VGND VPWR VPWR _0344_
+ sky130_fd_sc_hd__o221a_1
X_4128_ UART1.UART_TX1.index\[0\] UART1.UART_TX1.packet\[8\] UART1.UART_TX1.index\[1\]
+ VGND VGND VPWR VPWR _1851_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_14_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3292_ RAM1.mem\[6\]\[2\] _1157_ _1115_ _1217_ VGND VGND VPWR VPWR _1218_ sky130_fd_sc_hd__o211a_1
XFILLER_0_57_22 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3430_ RAM1.mem\[14\]\[7\] _1135_ _1115_ _1350_ VGND VGND VPWR VPWR _1351_ sky130_fd_sc_hd__o211a_1
X_2312_ net13 _2095_ _2096_ VGND VGND VPWR VPWR _2097_ sky130_fd_sc_hd__or3b_1
X_3361_ RAM1.mem\[16\]\[5\] RAM1.mem\[17\]\[5\] _1119_ VGND VGND VPWR VPWR _1284_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_161 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2243_ _2030_ _2031_ _2034_ _2035_ VGND VGND VPWR VPWR _2036_ sky130_fd_sc_hd__a31o_2
X_2174_ _1955_ _1972_ VGND VGND VPWR VPWR _1973_ sky130_fd_sc_hd__and2_1
XFILLER_0_28_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3628_ _1492_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__clkbuf_1
Xoutput39 net39 VGND VGND VPWR VPWR tx_reg[0] sky130_fd_sc_hd__clkbuf_4
Xoutput28 net28 VGND VGND VPWR VPWR cmd_byte[7] sky130_fd_sc_hd__clkbuf_4
Xoutput17 net17 VGND VGND VPWR VPWR addr_byte[4] sky130_fd_sc_hd__clkbuf_4
X_3559_ _0390_ RAM1.mem\[1\]\[3\] _1435_ VGND VGND VPWR VPWR _1444_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_194 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2930_ CPU1.RF1.rf\[0\]\[7\] _0850_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__or2_1
XFILLER_0_84_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_84_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2861_ CPU1.mdr_out\[4\] _0827_ _0829_ net73 VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__a22o_2
XFILLER_0_69_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4600_ clknet_leaf_22_clk _0377_ VGND VGND VPWR VPWR UART1.UART_TX1.packet\[2\] sky130_fd_sc_hd__dfxtp_1
XPHY_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4462_ clknet_leaf_9_clk _0241_ VGND VGND VPWR VPWR RAM1.mem\[2\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_3413_ _0516_ _1312_ _1316_ _1334_ VGND VGND VPWR VPWR _1335_ sky130_fd_sc_hd__o31ai_4
XFILLER_0_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4531_ clknet_leaf_25_clk _0308_ VGND VGND VPWR VPWR UART1.UART_RX1.index\[0\] sky130_fd_sc_hd__dfxtp_1
X_2792_ RAM1.mem\[18\]\[7\] RAM1.mem\[19\]\[7\] _0612_ VGND VGND VPWR VPWR _0782_
+ sky130_fd_sc_hd__mux2_1
XTAP_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3344_ RAM1.mem\[2\]\[4\] RAM1.mem\[3\]\[4\] _1155_ VGND VGND VPWR VPWR _1268_ sky130_fd_sc_hd__mux2_1
XTAP_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2226_ _2017_ _2018_ _2019_ _2021_ VGND VGND VPWR VPWR _2022_ sky130_fd_sc_hd__or4_1
X_4393_ clknet_leaf_19_clk _0172_ VGND VGND VPWR VPWR RAM1.mem\[9\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_3275_ RAM1.mem\[18\]\[2\] RAM1.mem\[19\]\[2\] _1122_ VGND VGND VPWR VPWR _1201_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_84_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2157_ net7 _1955_ VGND VGND VPWR VPWR _1956_ sky130_fd_sc_hd__or2_4
XFILLER_0_16_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_178 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_90_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_101_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3060_ _0998_ _0982_ _1000_ _1001_ VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_38_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2913_ net154 _0847_ _0868_ _0870_ _0623_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__o221a_1
XFILLER_0_72_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2844_ _0822_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__clkbuf_1
X_3962_ _2004_ UART1.UART_RX1.index\[2\] UART1.UART_RX1.index\[1\] UART1.UART_RX1.index\[0\]
+ VGND VGND VPWR VPWR _1724_ sky130_fd_sc_hd__or4b_1
X_3893_ _1674_ _2104_ _1672_ VGND VGND VPWR VPWR _1675_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4376_ clknet_leaf_8_clk _0155_ VGND VGND VPWR VPWR CPU1.mdr_out\[0\] sky130_fd_sc_hd__dfxtp_1
Xhold113 net44 VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__dlygate4sd3_1
X_2775_ _1946_ _0765_ VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__and2_1
X_4514_ clknet_leaf_17_clk _0291_ VGND VGND VPWR VPWR RAM1.mem\[16\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_4445_ clknet_leaf_19_clk _0224_ VGND VGND VPWR VPWR RAM1.mem\[19\]\[5\] sky130_fd_sc_hd__dfxtp_1
Xhold102 uart_curr_state\[6\] VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__dlygate4sd3_1
X_3258_ RAM1.mem\[0\]\[1\] _1137_ _2078_ _1184_ VGND VGND VPWR VPWR _1185_ sky130_fd_sc_hd__o211a_1
X_3327_ net78 _1113_ _1251_ _1092_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__o211a_1
XTAP_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3189_ _1116_ VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__clkbuf_4
XTAP_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2209_ _2004_ _2005_ _2002_ VGND VGND VPWR VPWR _2006_ sky130_fd_sc_hd__nand3_1
XFILLER_0_51_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2491_ RAM1.mem\[22\]\[0\] _0455_ _0519_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2560_ net31 _0560_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__or2_1
XFILLER_0_10_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4230_ clknet_leaf_19_clk _0025_ VGND VGND VPWR VPWR RAM1.mem\[8\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_4092_ CPU1.RF1.rf\[3\]\[7\] CPU1.RF1.rf\[2\]\[7\] _1790_ VGND VGND VPWR VPWR _1824_
+ sky130_fd_sc_hd__mux2_1
X_3112_ _1008_ _1051_ _0901_ VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__mux2_1
XFILLER_0_65_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3043_ net49 _0914_ _0901_ _0985_ VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__a31o_1
X_4161_ UART1.UART_TX1.clkCount\[1\] UART1.UART_TX1.clkCount\[0\] VGND VGND VPWR VPWR
+ _1877_ sky130_fd_sc_hd__nor2_1
XFILLER_0_81_21 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3945_ net143 VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_83_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2758_ RAM1.mem\[0\]\[6\] RAM1.mem\[1\]\[6\] _0493_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_156 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3876_ _1662_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_33_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2827_ net80 _0807_ _0810_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__a21oi_1
X_2689_ RAM1.mem\[4\]\[3\] RAM1.mem\[5\]\[3\] _0593_ VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__mux2_1
X_4359_ clknet_leaf_2_clk _0138_ VGND VGND VPWR VPWR CPU1.PC1.pc_out\[0\] sky130_fd_sc_hd__dfxtp_2
X_4428_ clknet_leaf_18_clk _0207_ VGND VGND VPWR VPWR RAM1.mem\[18\]\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3730_ _0437_ _1559_ _1555_ VGND VGND VPWR VPWR _1560_ sky130_fd_sc_hd__mux2_1
XFILLER_0_82_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2612_ _0605_ _0606_ _0608_ _0600_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__o211a_1
X_3661_ _1515_ _2104_ _1513_ VGND VGND VPWR VPWR _1516_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3592_ _1467_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_27_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2543_ net142 _0550_ _0553_ _0545_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__o211a_1
X_4213_ net128 VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__clkbuf_1
X_2474_ RAM1.mem\[11\]\[4\] _0476_ _0490_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__mux2_1
X_4075_ CPU1.RF1.rf\[0\]\[4\] _1792_ VGND VGND VPWR VPWR _1810_ sky130_fd_sc_hd__or2_1
X_3026_ CPU1.instr_reg_out\[5\] _0898_ _0968_ _2028_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__a22o_2
X_4144_ _1861_ _1862_ _1864_ VGND VGND VPWR VPWR _1865_ sky130_fd_sc_hd__and3b_1
XFILLER_0_65_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3928_ UART1.UART_RX1.index\[2\] UART1.UART_RX1.index\[1\] UART1.UART_RX1.index\[0\]
+ VGND VGND VPWR VPWR _1701_ sky130_fd_sc_hd__nand3_1
XFILLER_0_41_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3859_ _2098_ _1457_ VGND VGND VPWR VPWR _1651_ sky130_fd_sc_hd__nor2_4
XFILLER_0_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_46 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2190_ _1988_ VGND VGND VPWR VPWR _1989_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_1_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3713_ _0832_ _1550_ _1551_ net99 VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__a22o_1
XFILLER_0_70_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3644_ _1503_ _0399_ _1495_ VGND VGND VPWR VPWR _1504_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3575_ _0461_ _1454_ VGND VGND VPWR VPWR _1455_ sky130_fd_sc_hd__nor2_4
Xhold28 CPU1.RF1.rf\[2\]\[4\] VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dlygate4sd3_1
X_2388_ _0437_ _0438_ _0432_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__mux2_1
Xhold39 CPU1.mdr_out\[4\] VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dlygate4sd3_1
Xhold17 CPU1.mdr_out\[1\] VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__dlygate4sd3_1
X_2457_ _0493_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__clkbuf_4
X_2526_ net24 _0540_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__or2_1
X_4058_ _1372_ _2056_ _1796_ _0857_ VGND VGND VPWR VPWR _1797_ sky130_fd_sc_hd__a31o_1
X_3009_ _0916_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__buf_2
X_4127_ _1844_ _1845_ _1848_ _1849_ VGND VGND VPWR VPWR _1850_ sky130_fd_sc_hd__o211a_1
XFILLER_0_61_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_173 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_37_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3291_ RAM1.mem\[7\]\[2\] _1158_ VGND VGND VPWR VPWR _1217_ sky130_fd_sc_hd__or2_1
X_3360_ _1134_ _1280_ _1282_ _1125_ VGND VGND VPWR VPWR _1283_ sky130_fd_sc_hd__o211a_1
XFILLER_0_57_34 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2242_ CPU1.instr_reg_out\[2\] _2031_ CPU1.instr_reg_out\[1\] CPU1.instr_reg_out\[3\]
+ VGND VGND VPWR VPWR _2035_ sky130_fd_sc_hd__and4bb_1
X_2311_ _1919_ _2085_ VGND VGND VPWR VPWR _2096_ sky130_fd_sc_hd__and2_1
XFILLER_0_20_173 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_73_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2173_ net5 _1954_ net6 VGND VGND VPWR VPWR _1972_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_28_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput18 net18 VGND VGND VPWR VPWR addr_byte[5] sky130_fd_sc_hd__clkbuf_4
X_3558_ _1443_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__clkbuf_1
X_2509_ _0533_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__clkbuf_1
X_3627_ _1491_ _0417_ _1477_ VGND VGND VPWR VPWR _1492_ sky130_fd_sc_hd__mux2_1
Xoutput29 net29 VGND VGND VPWR VPWR data_byte[0] sky130_fd_sc_hd__clkbuf_4
X_3489_ _1394_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__clkbuf_1
XPHY_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2860_ _0824_ _0825_ _0834_ _0831_ net66 VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__a32o_1
XFILLER_0_84_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_69_195 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_43_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2791_ RAM1.mem\[16\]\[7\] RAM1.mem\[17\]\[7\] _0496_ VGND VGND VPWR VPWR _0781_
+ sky130_fd_sc_hd__mux2_1
XPHY_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4461_ clknet_leaf_10_clk _0240_ VGND VGND VPWR VPWR RAM1.mem\[2\]\[5\] sky130_fd_sc_hd__dfxtp_1
XTAP_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3412_ _0517_ _1320_ _1324_ _1333_ VGND VGND VPWR VPWR _1334_ sky130_fd_sc_hd__a31o_1
X_4530_ clknet_leaf_9_clk _0307_ VGND VGND VPWR VPWR RAM1.mem\[15\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_7_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4392_ clknet_leaf_20_clk _0171_ VGND VGND VPWR VPWR RAM1.mem\[9\]\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3343_ _1128_ _1264_ _1266_ _1131_ VGND VGND VPWR VPWR _1267_ sky130_fd_sc_hd__a211o_1
X_3274_ RAM1.mem\[16\]\[2\] RAM1.mem\[17\]\[2\] _1119_ VGND VGND VPWR VPWR _1200_
+ sky130_fd_sc_hd__mux2_1
X_2225_ UART1.UART_RX1.clkCount\[6\] _1979_ _2020_ VGND VGND VPWR VPWR _2021_ sky130_fd_sc_hd__a21o_1
XFILLER_0_75_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2156_ net5 net6 _1954_ VGND VGND VPWR VPWR _1955_ sky130_fd_sc_hd__or3_1
Xclkbuf_leaf_18_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_18_clk sky130_fd_sc_hd__clkbuf_16
X_2989_ net26 net25 _1921_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__and3b_1
XFILLER_0_101_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_290 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_97_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2912_ _0852_ _2056_ _0869_ _0857_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__a31o_1
X_3961_ net112 _1720_ _1723_ _1308_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__o211a_1
XFILLER_0_72_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2774_ net45 _0764_ _0574_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__mux2_1
X_2843_ _0799_ _0821_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__and2_1
X_3892_ RAM1.mem\[15\]\[1\] _0467_ _1669_ VGND VGND VPWR VPWR _1674_ sky130_fd_sc_hd__mux2_1
X_4513_ clknet_leaf_1_clk net54 VGND VGND VPWR VPWR UART1.UART_RX1.regIn sky130_fd_sc_hd__dfxtp_2
Xclkbuf_leaf_7_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_7_clk sky130_fd_sc_hd__clkbuf_16
X_4375_ clknet_leaf_4_clk _0154_ VGND VGND VPWR VPWR CPU1.alu_reg_out\[6\] sky130_fd_sc_hd__dfxtp_1
X_3326_ _1112_ _1250_ VGND VGND VPWR VPWR _1251_ sky130_fd_sc_hd__nand2_1
Xhold103 CPU1.PC1.pc_out\[5\] VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__dlygate4sd3_1
Xhold114 CPU1.z_flag_out VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4444_ clknet_leaf_18_clk _0223_ VGND VGND VPWR VPWR RAM1.mem\[19\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_3257_ RAM1.mem\[1\]\[1\] _1158_ VGND VGND VPWR VPWR _1184_ sky130_fd_sc_hd__or2_1
X_3188_ _1115_ VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__clkbuf_4
XTAP_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2208_ UART1.UART_RX1.state\[1\] VGND VGND VPWR VPWR _2005_ sky130_fd_sc_hd__clkbuf_4
X_2139_ UART1.RX_done uart_curr_state\[4\] VGND VGND VPWR VPWR _1942_ sky130_fd_sc_hd__and2b_1
XFILLER_0_8_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2490_ _0461_ _0518_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__nor2_4
XFILLER_0_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4160_ UART1.UART_TX1.clkCount\[1\] UART1.UART_TX1.clkCount\[0\] VGND VGND VPWR VPWR
+ _1876_ sky130_fd_sc_hd__and2_1
X_4091_ CPU1.RF1.rf\[1\]\[7\] _1791_ _1822_ _1794_ VGND VGND VPWR VPWR _1823_ sky130_fd_sc_hd__o211a_1
X_3111_ _0913_ _1029_ VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__nor2_1
X_3042_ _0900_ _0984_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__nor2_1
XFILLER_0_81_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3875_ _1661_ _0404_ _1651_ VGND VGND VPWR VPWR _1662_ sky130_fd_sc_hd__mux2_1
X_3944_ UART1.RX_dataOut\[2\] net131 _1710_ VGND VGND VPWR VPWR _1713_ sky130_fd_sc_hd__mux2_1
X_2688_ RAM1.mem\[6\]\[3\] _0586_ _0583_ RAM1.mem\[7\]\[3\] _0589_ VGND VGND VPWR
+ VPWR _0682_ sky130_fd_sc_hd__a221o_1
XFILLER_0_76_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2757_ RAM1.mem\[4\]\[6\] RAM1.mem\[5\]\[6\] _0494_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__mux2_1
XFILLER_0_53_190 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2826_ net80 _0807_ _0799_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__o21ai_1
X_4358_ clknet_leaf_5_clk _0137_ VGND VGND VPWR VPWR CPU1.RF1.rf\[2\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_4289_ clknet_leaf_1_clk _0080_ VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__dfxtp_2
X_4427_ clknet_leaf_18_clk _0206_ VGND VGND VPWR VPWR RAM1.mem\[18\]\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3309_ RAM1.mem\[8\]\[3\] _1138_ _1139_ _1233_ VGND VGND VPWR VPWR _1234_ sky130_fd_sc_hd__o211a_1
XFILLER_0_76_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2611_ _0595_ _0607_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__or2_1
X_3660_ RAM1.mem\[23\]\[1\] _0467_ _1511_ VGND VGND VPWR VPWR _1515_ sky130_fd_sc_hd__mux2_1
X_2542_ net15 _1944_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__or2_1
X_3591_ _1466_ _0399_ _1458_ VGND VGND VPWR VPWR _1467_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4212_ net127 net43 _1989_ VGND VGND VPWR VPWR _1915_ sky130_fd_sc_hd__mux2_1
X_2473_ _0506_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__clkbuf_1
X_4143_ UART1.UART_TX1.index\[0\] _1863_ VGND VGND VPWR VPWR _1864_ sky130_fd_sc_hd__or2_1
X_4074_ CPU1.reg_b_out\[3\] _0846_ _1807_ _1809_ _0879_ VGND VGND VPWR VPWR _0347_
+ sky130_fd_sc_hd__o221a_1
X_3025_ CPU1.instr_reg_out\[6\] _2036_ _2044_ CPU1.reg_b_out\[2\] VGND VGND VPWR VPWR
+ _0968_ sky130_fd_sc_hd__a22o_1
X_3858_ _2067_ RAM1.mem\[16\]\[0\] _1649_ VGND VGND VPWR VPWR _1650_ sky130_fd_sc_hd__mux2_1
X_3927_ _1694_ _1688_ _1692_ UART1.UART_RX1.index\[2\] VGND VGND VPWR VPWR _1700_
+ sky130_fd_sc_hd__a31o_1
X_3789_ _1601_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__clkbuf_1
X_2809_ _2058_ _0797_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__nor2_1
XFILLER_0_26_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3712_ _0830_ _1550_ _1551_ net87 VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__a22o_1
X_3574_ _2068_ _0516_ _0517_ VGND VGND VPWR VPWR _1454_ sky130_fd_sc_hd__or3_4
X_2525_ net142 _1937_ _0543_ _1940_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__o211a_1
XFILLER_0_30_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3643_ RAM1.mem\[19\]\[4\] _0476_ _1493_ VGND VGND VPWR VPWR _1503_ sky130_fd_sc_hd__mux2_1
Xhold29 CPU1.RF1.rf\[0\]\[3\] VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dlygate4sd3_1
Xhold18 CPU1.RF1.rf\[2\]\[3\] VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__dlygate4sd3_1
X_2387_ _2108_ RAM1.mem\[0\]\[2\] _0423_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__mux2_1
X_2456_ _1948_ _0492_ VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__nor2_2
X_4126_ UART1.UART_TX1.index\[3\] VGND VGND VPWR VPWR _1849_ sky130_fd_sc_hd__inv_2
X_4057_ CPU1.RF1.rf\[3\]\[0\] CPU1.RF1.rf\[2\]\[0\] _1791_ VGND VGND VPWR VPWR _1796_
+ sky130_fd_sc_hd__mux2_1
X_3008_ _0924_ _0950_ _0951_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__and3_1
XFILLER_0_46_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3290_ RAM1.mem\[4\]\[2\] RAM1.mem\[5\]\[2\] _1155_ VGND VGND VPWR VPWR _1216_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2241_ _2032_ _2033_ VGND VGND VPWR VPWR _2034_ sky130_fd_sc_hd__nand2_1
X_2310_ net14 _2090_ VGND VGND VPWR VPWR _2095_ sky130_fd_sc_hd__and2_2
X_2172_ UART1.UART_TX1.clkCount\[3\] _1964_ _1967_ UART1.UART_TX1.clkCount\[2\] _1970_
+ VGND VGND VPWR VPWR _1971_ sky130_fd_sc_hd__o221a_1
XFILLER_0_20_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3557_ _0437_ _1442_ _1438_ VGND VGND VPWR VPWR _1443_ sky130_fd_sc_hd__mux2_1
X_2508_ _0443_ _0532_ _0524_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__mux2_1
X_3626_ _0414_ RAM1.mem\[17\]\[7\] _1475_ VGND VGND VPWR VPWR _1491_ sky130_fd_sc_hd__mux2_1
Xoutput19 net19 VGND VGND VPWR VPWR addr_byte[6] sky130_fd_sc_hd__clkbuf_4
X_3488_ _1393_ _0411_ _1381_ VGND VGND VPWR VPWR _1394_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2439_ _0401_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__clkbuf_8
X_4109_ _0396_ RAM1.mem\[12\]\[4\] _1826_ VGND VGND VPWR VPWR _1836_ sky130_fd_sc_hd__mux2_1
XPHY_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xmax_cap50 _2045_ VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__buf_1
XFILLER_0_43_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2790_ _0580_ _0774_ _0775_ _0779_ _0426_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__a311o_1
XFILLER_0_25_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4460_ clknet_leaf_10_clk _0239_ VGND VGND VPWR VPWR RAM1.mem\[2\]\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4391_ clknet_leaf_4_clk _0170_ VGND VGND VPWR VPWR CPU1.instr_reg_out\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3411_ _1149_ _1328_ _1332_ _1162_ VGND VGND VPWR VPWR _1333_ sky130_fd_sc_hd__a31o_1
X_3342_ RAM1.mem\[14\]\[4\] _1144_ _1145_ _1265_ VGND VGND VPWR VPWR _1266_ sky130_fd_sc_hd__o211a_1
XFILLER_0_25_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3273_ _1134_ _1196_ _1198_ _1125_ VGND VGND VPWR VPWR _1199_ sky130_fd_sc_hd__o211a_1
X_2224_ UART1.UART_RX1.clkCount\[5\] _1977_ VGND VGND VPWR VPWR _2020_ sky130_fd_sc_hd__xnor2_1
X_2155_ net3 net4 net1 net2 VGND VGND VPWR VPWR _1954_ sky130_fd_sc_hd__or4_4
XFILLER_0_101_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3609_ _1479_ _2105_ _1477_ VGND VGND VPWR VPWR _1480_ sky130_fd_sc_hd__mux2_1
X_2988_ net23 _1919_ net38 net24 VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__and4b_1
X_4589_ clknet_leaf_25_clk _0366_ VGND VGND VPWR VPWR UART1.UART_TX1.clkCount\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_81_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2911_ CPU1.RF1.rf\[3\]\[3\] CPU1.RF1.rf\[2\]\[3\] _0848_ VGND VGND VPWR VPWR _0869_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3891_ _1673_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__clkbuf_1
X_3960_ _2005_ _1722_ _1720_ VGND VGND VPWR VPWR _1723_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_79_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_11 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold104 CPU1.PC1.pc_out\[1\] VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__dlygate4sd3_1
Xhold115 CPU1.PC1.pc_out\[4\] VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__dlygate4sd3_1
X_2773_ CPU1.PC1.pc_out\[6\] _1926_ _0763_ _1923_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__a22o_1
X_4512_ clknet_leaf_1_clk net12 VGND VGND VPWR VPWR UART1.UART_RX1.regInMeta sky130_fd_sc_hd__dfxtp_1
X_2842_ UART1.UART_RX1.clkCount\[9\] _0818_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_13_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3256_ RAM1.mem\[2\]\[1\] RAM1.mem\[3\]\[1\] _0459_ VGND VGND VPWR VPWR _1183_ sky130_fd_sc_hd__mux2_1
X_4374_ clknet_leaf_4_clk _0153_ VGND VGND VPWR VPWR CPU1.alu_reg_out\[5\] sky130_fd_sc_hd__dfxtp_1
X_3325_ _0516_ _1227_ _1231_ _1249_ VGND VGND VPWR VPWR _1250_ sky130_fd_sc_hd__o31ai_4
XTAP_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4443_ clknet_leaf_19_clk _0222_ VGND VGND VPWR VPWR RAM1.mem\[19\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3187_ _1114_ VGND VGND VPWR VPWR _1115_ sky130_fd_sc_hd__clkbuf_4
XTAP_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2138_ _1919_ VGND VGND VPWR VPWR _1941_ sky130_fd_sc_hd__clkbuf_4
X_2207_ UART1.UART_RX1.index\[3\] VGND VGND VPWR VPWR _2004_ sky130_fd_sc_hd__buf_2
XFILLER_0_36_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_230 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3110_ _0953_ _1004_ _1049_ _0956_ VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__o211a_1
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4090_ CPU1.RF1.rf\[0\]\[7\] _1792_ VGND VGND VPWR VPWR _1822_ sky130_fd_sc_hd__or2_1
XFILLER_0_77_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3041_ _0913_ _0907_ _0918_ VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_45_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3874_ _0402_ RAM1.mem\[16\]\[5\] _1649_ VGND VGND VPWR VPWR _1661_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_211 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2825_ _0809_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3943_ net114 VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__clkbuf_1
X_2687_ RAM1.mem\[2\]\[3\] _0582_ _0497_ RAM1.mem\[3\]\[3\] _0428_ VGND VGND VPWR
+ VPWR _0681_ sky130_fd_sc_hd__a221o_1
XFILLER_0_69_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2756_ _0577_ _0745_ _0746_ _2093_ VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__a31o_1
X_4426_ clknet_leaf_19_clk _0205_ VGND VGND VPWR VPWR RAM1.mem\[18\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_4357_ clknet_leaf_5_clk _0136_ VGND VGND VPWR VPWR CPU1.RF1.rf\[2\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_3239_ net74 _1113_ _1166_ _1092_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__o211a_1
X_4288_ clknet_leaf_0_clk _0079_ VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__dfxtp_2
XTAP_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3308_ RAM1.mem\[9\]\[3\] _2076_ VGND VGND VPWR VPWR _1233_ sky130_fd_sc_hd__or2_1
XFILLER_0_51_128 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2610_ RAM1.mem\[0\]\[0\] RAM1.mem\[1\]\[0\] _0596_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2472_ _0505_ _0393_ _0499_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__mux2_1
X_3590_ RAM1.mem\[18\]\[4\] _0476_ _1455_ VGND VGND VPWR VPWR _1466_ sky130_fd_sc_hd__mux2_1
X_2541_ net113 _0550_ _0552_ _0545_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__o211a_1
X_4073_ _1372_ _2055_ _1808_ _0856_ VGND VGND VPWR VPWR _1809_ sky130_fd_sc_hd__a31o_1
XFILLER_0_76_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4211_ _1914_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__clkbuf_1
X_4142_ _1858_ _1860_ VGND VGND VPWR VPWR _1863_ sky130_fd_sc_hd__and2b_1
XFILLER_0_92_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3024_ net157 _0941_ _0967_ _0569_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__o211a_1
X_3788_ _0440_ _1600_ _1594_ VGND VGND VPWR VPWR _1601_ sky130_fd_sc_hd__mux2_1
X_3857_ _2080_ _1474_ VGND VGND VPWR VPWR _1649_ sky130_fd_sc_hd__nand2_4
XFILLER_0_41_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2808_ run_reg _0793_ _0796_ _0791_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__o2bb2a_1
X_3926_ _1699_ VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__clkbuf_1
X_2739_ _0591_ _0728_ _0730_ _0600_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__o211a_1
X_4409_ clknet_leaf_17_clk _0188_ VGND VGND VPWR VPWR RAM1.mem\[20\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3711_ _1951_ _1550_ VGND VGND VPWR VPWR _1551_ sky130_fd_sc_hd__nor2_2
X_3642_ _1502_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_87_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3573_ _1453_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__clkbuf_1
X_2455_ net13 _2090_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__nand2_2
X_2524_ net23 _0540_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__or2_1
Xhold19 CPU1.RF1.rf\[2\]\[0\] VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__dlygate4sd3_1
X_4056_ CPU1.RF1.rf\[1\]\[0\] _1791_ _1793_ _1794_ VGND VGND VPWR VPWR _1795_ sky130_fd_sc_hd__o211a_1
X_2386_ _2110_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__buf_2
X_4125_ UART1.UART_TX1.index\[1\] _1846_ _1847_ UART1.UART_TX1.index\[2\] VGND VGND
+ VPWR VPWR _1848_ sky130_fd_sc_hd__a211o_1
XFILLER_0_52_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3007_ _0948_ _0949_ _0942_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__a21o_1
X_3909_ _1685_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2240_ CPU1.instr_reg_out\[2\] VGND VGND VPWR VPWR _2033_ sky130_fd_sc_hd__clkbuf_4
X_2171_ UART1.UART_TX1.clkCount\[2\] _1967_ _1968_ UART1.UART_TX1.clkCount\[1\] _1969_
+ VGND VGND VPWR VPWR _1970_ sky130_fd_sc_hd__a221o_1
XFILLER_0_20_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3625_ _1490_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3556_ _2108_ RAM1.mem\[1\]\[2\] _1435_ VGND VGND VPWR VPWR _1442_ sky130_fd_sc_hd__mux2_1
X_2507_ RAM1.mem\[22\]\[4\] _0476_ _0519_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__mux2_1
X_3487_ _0408_ RAM1.mem\[9\]\[6\] _1378_ VGND VGND VPWR VPWR _1393_ sky130_fd_sc_hd__mux2_1
X_2438_ _0478_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2369_ _2069_ _0421_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__nor2_2
X_4039_ _0476_ RAM1.mem\[13\]\[4\] _1771_ VGND VGND VPWR VPWR _1782_ sky130_fd_sc_hd__mux2_1
X_4108_ _1835_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_93_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmax_cap51 net52 VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_2
XPHY_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4390_ clknet_leaf_4_clk _0169_ VGND VGND VPWR VPWR CPU1.instr_reg_out\[6\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_68_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3410_ _1139_ _1329_ _1331_ _1190_ VGND VGND VPWR VPWR _1332_ sky130_fd_sc_hd__a211o_1
X_3272_ _1121_ _1197_ VGND VGND VPWR VPWR _1198_ sky130_fd_sc_hd__or2_1
X_3341_ RAM1.mem\[15\]\[4\] _2075_ VGND VGND VPWR VPWR _1265_ sky130_fd_sc_hd__or2_1
XTAP_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2154_ UART1.UART_TX1.index\[2\] UART1.UART_TX1.index\[1\] UART1.UART_TX1.index\[0\]
+ UART1.UART_TX1.index\[3\] VGND VGND VPWR VPWR _1953_ sky130_fd_sc_hd__and4bb_1
X_2223_ UART1.UART_RX1.clkCount\[8\] _1958_ VGND VGND VPWR VPWR _2019_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_17_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2987_ _2029_ _0931_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__and2_1
XFILLER_0_48_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3608_ _2102_ RAM1.mem\[17\]\[1\] _1475_ VGND VGND VPWR VPWR _1479_ sky130_fd_sc_hd__mux2_1
X_4588_ clknet_leaf_23_clk _0365_ VGND VGND VPWR VPWR UART1.UART_TX1.index\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_101_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3539_ _1429_ _0405_ _1419_ VGND VGND VPWR VPWR _1430_ sky130_fd_sc_hd__mux2_1
XFILLER_0_66_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_180 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2910_ CPU1.RF1.rf\[1\]\[3\] _0849_ _0867_ _0853_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__o211a_1
XFILLER_0_72_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3890_ _1670_ _2087_ _1672_ VGND VGND VPWR VPWR _1673_ sky130_fd_sc_hd__mux2_1
X_2841_ _0820_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4511_ clknet_leaf_8_clk _0290_ VGND VGND VPWR VPWR RAM1.mem\[7\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_2772_ _0521_ _0755_ _0762_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__a21o_1
Xhold105 net46 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__dlygate4sd3_1
Xhold116 UART1.UART_RX1.clkCount\[7\] VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__dlygate4sd3_1
X_4442_ clknet_leaf_19_clk _0221_ VGND VGND VPWR VPWR RAM1.mem\[19\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_95_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4373_ clknet_leaf_8_clk _0152_ VGND VGND VPWR VPWR CPU1.alu_reg_out\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3324_ _0517_ _1235_ _1239_ _1248_ VGND VGND VPWR VPWR _1249_ sky130_fd_sc_hd__a31o_1
XTAP_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3255_ _1128_ _1179_ _1181_ _1132_ VGND VGND VPWR VPWR _1182_ sky130_fd_sc_hd__a211o_1
XFILLER_0_0_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2206_ _2002_ UART1.UART_RX1.state\[3\] VGND VGND VPWR VPWR _2003_ sky130_fd_sc_hd__or2b_1
XFILLER_0_21_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_95_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3186_ _2061_ CPU1.PC1.pc_out\[1\] net52 CPU1.reg_b_out\[1\] VGND VGND VPWR VPWR
+ _1114_ sky130_fd_sc_hd__a22o_1
X_2137_ net119 _1936_ _1938_ _1940_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__o31a_1
XFILLER_0_36_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_10_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3040_ _0980_ _0981_ _0924_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_5_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2824_ _0807_ _0808_ _0799_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__and3b_1
XFILLER_0_18_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3942_ UART1.RX_dataOut\[1\] net107 _1710_ VGND VGND VPWR VPWR _1712_ sky130_fd_sc_hd__mux2_1
X_3873_ _1660_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__clkbuf_1
X_4356_ clknet_leaf_5_clk _0135_ VGND VGND VPWR VPWR CPU1.RF1.rf\[2\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_2755_ RAM1.mem\[14\]\[6\] _0492_ _0494_ RAM1.mem\[15\]\[6\] _0588_ VGND VGND VPWR
+ VPWR _0746_ sky130_fd_sc_hd__a221o_1
X_2686_ _0580_ _0674_ _0675_ _0679_ _2093_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__a311o_1
X_4425_ clknet_leaf_19_clk _0204_ VGND VGND VPWR VPWR RAM1.mem\[18\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_3169_ _1946_ _1102_ VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__and2_1
X_3238_ _1113_ _1165_ VGND VGND VPWR VPWR _1166_ sky130_fd_sc_hd__nand2_1
XTAP_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4287_ clknet_leaf_0_clk _0078_ VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__dfxtp_1
X_3307_ RAM1.mem\[10\]\[3\] RAM1.mem\[11\]\[3\] _1135_ VGND VGND VPWR VPWR _1232_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4210_ net123 net42 _1989_ VGND VGND VPWR VPWR _1914_ sky130_fd_sc_hd__mux2_1
XFILLER_0_35_192 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2540_ net14 _1944_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__or2_1
X_2471_ RAM1.mem\[11\]\[3\] _0473_ _0490_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__mux2_1
X_4072_ CPU1.RF1.rf\[3\]\[3\] CPU1.RF1.rf\[2\]\[3\] _1790_ VGND VGND VPWR VPWR _1808_
+ sky130_fd_sc_hd__mux2_1
X_3023_ net14 _0936_ _0966_ _0905_ _0937_ VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__a221o_1
X_4141_ _1858_ _1859_ _1939_ VGND VGND VPWR VPWR _1862_ sky130_fd_sc_hd__o21a_1
X_3925_ _1946_ _1698_ VGND VGND VPWR VPWR _1699_ sky130_fd_sc_hd__and2_1
X_2738_ _0595_ _0729_ VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__or2_1
X_3787_ _0473_ RAM1.mem\[5\]\[3\] _1591_ VGND VGND VPWR VPWR _1600_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3856_ _1648_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2807_ net28 net27 _0794_ _0795_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__or4_1
XFILLER_0_33_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4339_ clknet_leaf_7_clk _0127_ VGND VGND VPWR VPWR CPU1.reg_a_out\[5\] sky130_fd_sc_hd__dfxtp_1
X_4408_ clknet_leaf_17_clk _0187_ VGND VGND VPWR VPWR RAM1.mem\[20\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2669_ RAM1.mem\[18\]\[2\] RAM1.mem\[19\]\[2\] _0612_ VGND VGND VPWR VPWR _0664_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_21_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3710_ _1549_ VGND VGND VPWR VPWR _1550_ sky130_fd_sc_hd__buf_2
X_3572_ _0452_ _1452_ _1438_ VGND VGND VPWR VPWR _1453_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3641_ _1501_ _0393_ _1495_ VGND VGND VPWR VPWR _1502_ sky130_fd_sc_hd__mux2_1
XFILLER_0_23_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2385_ _0436_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_87_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2523_ net113 _1937_ _0542_ _1940_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__o211a_1
X_2454_ RAM1.mem\[11\]\[0\] _0455_ _0490_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__mux2_1
XFILLER_0_23_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput1 clk_per_bit[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_4
X_4055_ _1372_ _2055_ VGND VGND VPWR VPWR _1794_ sky130_fd_sc_hd__nand2_2
X_3006_ _0942_ _0948_ _0949_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__nand3_1
XFILLER_0_36_71 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4124_ UART1.UART_TX1.index\[1\] UART1.UART_TX1.index\[0\] UART1.UART_TX1.packet\[1\]
+ VGND VGND VPWR VPWR _1847_ sky130_fd_sc_hd__and3b_1
X_3908_ _1684_ _0410_ _1672_ VGND VGND VPWR VPWR _1685_ sky130_fd_sc_hd__mux2_1
X_3839_ RAM1.mem\[7\]\[2\] _2107_ _1630_ VGND VGND VPWR VPWR _1637_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2170_ UART1.UART_TX1.clkCount\[0\] net1 _1968_ UART1.UART_TX1.clkCount\[1\] VGND
+ VGND VPWR VPWR _1969_ sky130_fd_sc_hd__o22a_1
XFILLER_0_101_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3555_ _1441_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__clkbuf_1
X_3624_ _1489_ _0411_ _1477_ VGND VGND VPWR VPWR _1490_ sky130_fd_sc_hd__mux2_1
X_2506_ _0531_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__clkbuf_1
X_2368_ _2070_ _0420_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__nand2_2
XFILLER_0_44_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3486_ _1392_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__clkbuf_1
X_2437_ _0477_ _0399_ _0465_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__mux2_1
XFILLER_0_93_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_66_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2299_ net28 net27 net24 net23 VGND VGND VPWR VPWR _2084_ sky130_fd_sc_hd__and4b_1
X_4038_ _1781_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__clkbuf_1
X_4107_ _1834_ _0392_ _1828_ VGND VGND VPWR VPWR _1835_ sky130_fd_sc_hd__mux2_1
XPHY_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmax_cap52 net53 VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_43_17 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3271_ RAM1.mem\[22\]\[2\] RAM1.mem\[23\]\[2\] _1122_ VGND VGND VPWR VPWR _1197_
+ sky130_fd_sc_hd__mux2_1
X_3340_ RAM1.mem\[12\]\[4\] RAM1.mem\[13\]\[4\] _1118_ VGND VGND VPWR VPWR _1264_
+ sky130_fd_sc_hd__mux2_1
X_2222_ UART1.UART_RX1.clkCount\[6\] _1979_ VGND VGND VPWR VPWR _2018_ sky130_fd_sc_hd__nor2_1
X_2153_ _1937_ _1950_ _1952_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_17_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2986_ _2030_ _2031_ _0930_ _2035_ CPU1.z_flag_out VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__a32o_1
XFILLER_0_16_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3538_ _0402_ RAM1.mem\[20\]\[5\] _1417_ VGND VGND VPWR VPWR _1429_ sky130_fd_sc_hd__mux2_1
X_4587_ clknet_leaf_23_clk _0364_ VGND VGND VPWR VPWR UART1.UART_TX1.index\[2\] sky130_fd_sc_hd__dfxtp_1
X_3607_ _1478_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__clkbuf_1
X_3469_ _2094_ _1380_ VGND VGND VPWR VPWR _1381_ sky130_fd_sc_hd__nor2_4
XFILLER_0_66_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2771_ _2092_ _0758_ _0761_ _0589_ _0429_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__o221a_1
XFILLER_0_45_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2840_ _0799_ _0818_ _0819_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__and3_1
Xhold106 CPU1.instr_reg_out\[4\] VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__dlygate4sd3_1
X_4372_ clknet_leaf_3_clk _0151_ VGND VGND VPWR VPWR CPU1.alu_reg_out\[3\] sky130_fd_sc_hd__dfxtp_1
X_4510_ clknet_leaf_8_clk _0289_ VGND VGND VPWR VPWR RAM1.mem\[7\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4441_ clknet_leaf_19_clk _0220_ VGND VGND VPWR VPWR RAM1.mem\[19\]\[1\] sky130_fd_sc_hd__dfxtp_1
Xhold117 UART1.UART_TX1.index\[2\] VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_95_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3323_ _1149_ _1243_ _1247_ _1162_ VGND VGND VPWR VPWR _1248_ sky130_fd_sc_hd__a31o_1
X_3185_ _1112_ VGND VGND VPWR VPWR _1113_ sky130_fd_sc_hd__buf_2
XTAP_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3254_ RAM1.mem\[14\]\[1\] _1144_ _1145_ _1180_ VGND VGND VPWR VPWR _1181_ sky130_fd_sc_hd__o211a_1
X_2205_ UART1.UART_RX1.clkCount\[9\] _1958_ _1985_ _2001_ VGND VGND VPWR VPWR _2002_
+ sky130_fd_sc_hd__o211a_2
XFILLER_0_21_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2136_ _1939_ VGND VGND VPWR VPWR _1940_ sky130_fd_sc_hd__clkbuf_4
X_2969_ CPU1.reg_a_out\[0\] _0902_ _0904_ CPU1.PC1.pc_out\[0\] VGND VGND VPWR VPWR
+ _0914_ sky130_fd_sc_hd__a22o_1
XFILLER_0_47_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_65_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3941_ _1711_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__clkbuf_1
X_2754_ RAM1.mem\[10\]\[6\] _0492_ _0494_ RAM1.mem\[11\]\[6\] _0427_ VGND VGND VPWR
+ VPWR _0745_ sky130_fd_sc_hd__a221o_1
XFILLER_0_38_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2823_ UART1.UART_RX1.clkCount\[3\] _0804_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__or2_1
X_3872_ _1659_ _0398_ _1651_ VGND VGND VPWR VPWR _1660_ sky130_fd_sc_hd__mux2_1
X_4355_ clknet_leaf_5_clk _0134_ VGND VGND VPWR VPWR CPU1.RF1.rf\[2\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_39_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3306_ _1117_ _1228_ _1230_ _1132_ VGND VGND VPWR VPWR _1231_ sky130_fd_sc_hd__o211a_1
XTAP_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4424_ clknet_leaf_19_clk _0203_ VGND VGND VPWR VPWR RAM1.mem\[18\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_2685_ _0591_ _0676_ _0678_ _0600_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__o211a_1
X_3168_ CPU1.alu_reg_out\[1\] _0966_ _1094_ VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__mux2_1
X_3237_ _0516_ _1126_ _1133_ _1164_ VGND VGND VPWR VPWR _1165_ sky130_fd_sc_hd__o31ai_4
X_2119_ net28 net27 VGND VGND VPWR VPWR _1927_ sky130_fd_sc_hd__nand2_1
X_4286_ clknet_leaf_0_clk _0077_ VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__dfxtp_1
XTAP_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3099_ _2028_ _0991_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__and2_1
XFILLER_0_91_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2470_ _0504_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4140_ _1858_ _1860_ UART1.UART_TX1.index\[0\] VGND VGND VPWR VPWR _1861_ sky130_fd_sc_hd__and3b_1
X_4071_ CPU1.RF1.rf\[1\]\[3\] _1791_ _1806_ _1794_ VGND VGND VPWR VPWR _1807_ sky130_fd_sc_hd__o211a_1
X_3022_ _0952_ _0959_ _0965_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__or3b_2
X_3924_ _1694_ _1697_ _1692_ VGND VGND VPWR VPWR _1698_ sky130_fd_sc_hd__mux2_1
X_2737_ RAM1.mem\[0\]\[5\] RAM1.mem\[1\]\[5\] _0596_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__mux2_1
X_3786_ _1599_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_74_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3855_ _0452_ _1647_ _1633_ VGND VGND VPWR VPWR _1648_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2806_ net24 net23 VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__nand2_1
X_2668_ RAM1.mem\[16\]\[2\] RAM1.mem\[17\]\[2\] _0612_ VGND VGND VPWR VPWR _0663_
+ sky130_fd_sc_hd__mux2_1
X_4338_ clknet_leaf_6_clk _0126_ VGND VGND VPWR VPWR CPU1.reg_a_out\[4\] sky130_fd_sc_hd__dfxtp_1
X_4407_ clknet_leaf_13_clk _0186_ VGND VGND VPWR VPWR RAM1.mem\[21\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_4269_ clknet_leaf_13_clk _0060_ VGND VGND VPWR VPWR RAM1.mem\[22\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_2599_ _0493_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__buf_4
XFILLER_0_5_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_163 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_99_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_308 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3571_ _0414_ RAM1.mem\[1\]\[7\] _1435_ VGND VGND VPWR VPWR _1452_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2522_ net22 _0540_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__or2_1
X_3640_ RAM1.mem\[19\]\[3\] _0473_ _1493_ VGND VGND VPWR VPWR _1501_ sky130_fd_sc_hd__mux2_1
X_2384_ _0434_ _0435_ _0432_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__mux2_1
X_4123_ UART1.UART_TX1.packet\[2\] UART1.UART_TX1.packet\[3\] UART1.UART_TX1.index\[0\]
+ VGND VGND VPWR VPWR _1846_ sky130_fd_sc_hd__mux2_1
X_2453_ _0457_ _0489_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__nor2_4
X_4054_ CPU1.RF1.rf\[0\]\[0\] _1792_ VGND VGND VPWR VPWR _1793_ sky130_fd_sc_hd__or2_1
X_3005_ _0917_ _0946_ _0947_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__or3_4
XFILLER_0_36_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput2 clk_per_bit[1] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_2
X_3838_ _1636_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_93_306 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3907_ RAM1.mem\[15\]\[6\] _0482_ _1669_ VGND VGND VPWR VPWR _1684_ sky130_fd_sc_hd__mux2_1
X_3769_ _0408_ RAM1.mem\[4\]\[6\] _1572_ VGND VGND VPWR VPWR _1587_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_111 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_73_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_43_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3554_ _0434_ _1440_ _1438_ VGND VGND VPWR VPWR _1441_ sky130_fd_sc_hd__mux2_1
X_2505_ _0440_ _0530_ _0524_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__mux2_1
X_3623_ _0408_ RAM1.mem\[17\]\[6\] _1475_ VGND VGND VPWR VPWR _1489_ sky130_fd_sc_hd__mux2_1
X_3485_ _1391_ _0405_ _1381_ VGND VGND VPWR VPWR _1392_ sky130_fd_sc_hd__mux2_1
X_2367_ _2061_ CPU1.PC1.pc_out\[3\] _2065_ CPU1.reg_b_out\[3\] VGND VGND VPWR VPWR
+ _0420_ sky130_fd_sc_hd__a22oi_2
X_2298_ net22 net21 VGND VGND VPWR VPWR _2083_ sky130_fd_sc_hd__nor2_1
XFILLER_0_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2436_ RAM1.mem\[10\]\[4\] _0476_ _0462_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__mux2_1
X_4106_ _0390_ RAM1.mem\[12\]\[3\] _1826_ VGND VGND VPWR VPWR _1834_ sky130_fd_sc_hd__mux2_1
XFILLER_0_78_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_78_122 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4037_ _0393_ _1780_ _1774_ VGND VGND VPWR VPWR _1781_ sky130_fd_sc_hd__mux2_1
XFILLER_0_93_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap53 _2038_ VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_43_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_37 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_68_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3270_ RAM1.mem\[20\]\[2\] RAM1.mem\[21\]\[2\] _1138_ VGND VGND VPWR VPWR _1196_
+ sky130_fd_sc_hd__mux2_1
X_2152_ _1951_ VGND VGND VPWR VPWR _1952_ sky130_fd_sc_hd__clkbuf_4
X_2221_ UART1.UART_RX1.clkCount\[7\] _1960_ VGND VGND VPWR VPWR _2017_ sky130_fd_sc_hd__nor2_1
X_2985_ _2032_ CPU1.alu_reg_out\[7\] _0929_ VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_31_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3537_ _1428_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3468_ net14 _2086_ _0497_ VGND VGND VPWR VPWR _1380_ sky130_fd_sc_hd__nand3b_4
XFILLER_0_31_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4586_ clknet_leaf_23_clk _0363_ VGND VGND VPWR VPWR UART1.UART_TX1.index\[1\] sky130_fd_sc_hd__dfxtp_2
X_3606_ _1476_ _2088_ _1477_ VGND VGND VPWR VPWR _1478_ sky130_fd_sc_hd__mux2_1
X_3399_ RAM1.mem\[12\]\[6\] RAM1.mem\[13\]\[6\] _1118_ VGND VGND VPWR VPWR _1321_
+ sky130_fd_sc_hd__mux2_1
X_2419_ net13 _2095_ _2096_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__nand3b_4
XFILLER_0_57_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2770_ _0759_ _0760_ _0577_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3322_ _1154_ _1244_ _1246_ _1190_ VGND VGND VPWR VPWR _1247_ sky130_fd_sc_hd__a211o_1
XFILLER_0_80_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold107 CPU1.reg_b_out\[2\] VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__dlygate4sd3_1
X_4371_ clknet_leaf_3_clk _0150_ VGND VGND VPWR VPWR CPU1.alu_reg_out\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4440_ clknet_leaf_19_clk _0219_ VGND VGND VPWR VPWR RAM1.mem\[19\]\[0\] sky130_fd_sc_hd__dfxtp_1
Xhold118 UART1.UART_RX1.state\[2\] VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_21_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3184_ _1111_ VGND VGND VPWR VPWR _1112_ sky130_fd_sc_hd__clkbuf_2
XTAP_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3253_ RAM1.mem\[15\]\[1\] _2075_ VGND VGND VPWR VPWR _1180_ sky130_fd_sc_hd__or2_1
X_2204_ UART1.UART_RX1.clkCount\[8\] _1960_ _1958_ UART1.UART_RX1.clkCount\[9\] _2000_
+ VGND VGND VPWR VPWR _2001_ sky130_fd_sc_hd__a221o_1
X_2135_ net11 VGND VGND VPWR VPWR _1939_ sky130_fd_sc_hd__inv_2
XFILLER_0_48_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2899_ CPU1.RF1.rf\[0\]\[1\] _0850_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__or2_1
X_2968_ _0912_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__buf_2
X_4569_ clknet_leaf_7_clk _0346_ VGND VGND VPWR VPWR CPU1.reg_b_out\[2\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_12_272 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_79_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_39_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_49_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3940_ net136 net112 _1710_ VGND VGND VPWR VPWR _1711_ sky130_fd_sc_hd__mux2_1
X_3871_ _0396_ RAM1.mem\[16\]\[4\] _1649_ VGND VGND VPWR VPWR _1659_ sky130_fd_sc_hd__mux2_1
XFILLER_0_90_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2753_ _0588_ _0741_ _0743_ _0599_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__o211a_1
X_2822_ UART1.UART_RX1.clkCount\[3\] _0804_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__and2_1
X_2684_ _0584_ _0677_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__or2_1
X_4354_ clknet_leaf_5_clk _0133_ VGND VGND VPWR VPWR CPU1.RF1.rf\[2\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_4423_ clknet_leaf_10_clk _0202_ VGND VGND VPWR VPWR RAM1.mem\[1\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_3305_ _1121_ _1229_ VGND VGND VPWR VPWR _1230_ sky130_fd_sc_hd__or2_1
X_4285_ clknet_leaf_0_clk _0076_ VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__dfxtp_2
XTAP_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3098_ _0945_ _1017_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__nand2_1
XFILLER_0_68_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3167_ net104 _1094_ _1096_ _1092_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__o211a_1
XFILLER_0_55_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3236_ _0517_ _1142_ _1148_ _1163_ VGND VGND VPWR VPWR _1164_ sky130_fd_sc_hd__a31o_1
X_2118_ _1925_ VGND VGND VPWR VPWR _1926_ sky130_fd_sc_hd__buf_2
XTAP_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4070_ CPU1.RF1.rf\[0\]\[3\] _1792_ VGND VGND VPWR VPWR _1806_ sky130_fd_sc_hd__or2_1
X_3021_ _0953_ _0954_ _0960_ _0964_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__a31o_1
X_3854_ RAM1.mem\[7\]\[7\] _0413_ _1630_ VGND VGND VPWR VPWR _1647_ sky130_fd_sc_hd__mux2_1
X_2805_ net26 net25 VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__nand2_1
X_3923_ UART1.UART_RX1.state\[1\] _1695_ _1696_ VGND VGND VPWR VPWR _1697_ sky130_fd_sc_hd__and3_1
X_4406_ clknet_leaf_12_clk _0185_ VGND VGND VPWR VPWR RAM1.mem\[21\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_2736_ RAM1.mem\[4\]\[5\] RAM1.mem\[5\]\[5\] _0593_ VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__mux2_1
X_3785_ _0437_ _1598_ _1594_ VGND VGND VPWR VPWR _1599_ sky130_fd_sc_hd__mux2_1
X_2667_ _0579_ _0656_ _0657_ _0661_ _0426_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__a311o_1
XFILLER_0_67_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_250 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4337_ clknet_leaf_7_clk _0125_ VGND VGND VPWR VPWR CPU1.reg_a_out\[3\] sky130_fd_sc_hd__dfxtp_1
X_2598_ _0427_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__clkbuf_4
X_4268_ clknet_leaf_13_clk _0059_ VGND VGND VPWR VPWR RAM1.mem\[22\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_3219_ RAM1.mem\[14\]\[0\] _1144_ _1145_ _1146_ VGND VGND VPWR VPWR _1147_ sky130_fd_sc_hd__o211a_1
X_4199_ _2063_ _1905_ _1907_ VGND VGND VPWR VPWR _1908_ sky130_fd_sc_hd__and3_1
XFILLER_0_64_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_175 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3570_ _1451_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_87_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2521_ net130 _1937_ _0541_ _1940_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__o211a_1
XFILLER_0_11_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2383_ _2102_ RAM1.mem\[0\]\[1\] _0423_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__mux2_1
X_4053_ CPU1.instr_reg_out\[4\] CPU1.curr_state\[2\] VGND VGND VPWR VPWR _1792_ sky130_fd_sc_hd__and2_2
X_2452_ _0488_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__buf_6
X_4122_ UART1.UART_TX1.packet\[4\] UART1.UART_TX1.packet\[5\] UART1.UART_TX1.packet\[6\]
+ UART1.UART_TX1.packet\[7\] UART1.UART_TX1.index\[0\] UART1.UART_TX1.index\[1\] VGND
+ VGND VPWR VPWR _1845_ sky130_fd_sc_hd__mux4_1
XFILLER_0_93_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3004_ _0946_ _0947_ _0917_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__o21ai_1
Xinput3 clk_per_bit[2] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__buf_1
X_3837_ _0434_ _1635_ _1633_ VGND VGND VPWR VPWR _1636_ sky130_fd_sc_hd__mux2_1
X_3768_ _1586_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_61_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3906_ _1683_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__clkbuf_1
X_3699_ _1542_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2719_ _0710_ _0711_ _0578_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__mux2_2
XFILLER_0_93_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_123 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_87_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_98_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3622_ _1488_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_101_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3553_ _2102_ RAM1.mem\[1\]\[1\] _1435_ VGND VGND VPWR VPWR _1440_ sky130_fd_sc_hd__mux2_1
X_2504_ RAM1.mem\[22\]\[3\] _0473_ _0519_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__mux2_1
X_2435_ _0395_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__clkbuf_8
X_3484_ _0402_ RAM1.mem\[9\]\[5\] _1378_ VGND VGND VPWR VPWR _1391_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2366_ _2087_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__buf_2
X_4036_ _0473_ RAM1.mem\[13\]\[3\] _1771_ VGND VGND VPWR VPWR _1780_ sky130_fd_sc_hd__mux2_1
X_2297_ _2067_ RAM1.mem\[8\]\[0\] _2081_ VGND VGND VPWR VPWR _2082_ sky130_fd_sc_hd__mux2_1
X_4105_ _1833_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_126 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2151_ net11 VGND VGND VPWR VPWR _1951_ sky130_fd_sc_hd__clkbuf_8
X_2220_ UART1.UART_RX1.clkCount\[7\] _1960_ _2015_ VGND VGND VPWR VPWR _2016_ sky130_fd_sc_hd__a21o_1
X_2984_ _2032_ CPU1.z_flag_out _2033_ VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__a21o_1
X_3605_ _1380_ _1457_ VGND VGND VPWR VPWR _1477_ sky130_fd_sc_hd__nor2_4
XFILLER_0_3_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4585_ clknet_leaf_23_clk _0362_ VGND VGND VPWR VPWR UART1.UART_TX1.index\[0\] sky130_fd_sc_hd__dfxtp_2
X_3536_ _1427_ _0399_ _1419_ VGND VGND VPWR VPWR _1428_ sky130_fd_sc_hd__mux2_1
X_3398_ _1116_ _1317_ _1319_ _2069_ VGND VGND VPWR VPWR _1320_ sky130_fd_sc_hd__a211o_1
X_2418_ RAM1.mem\[10\]\[0\] _0455_ _0462_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__mux2_1
X_3467_ _2067_ RAM1.mem\[9\]\[0\] _1378_ VGND VGND VPWR VPWR _1379_ sky130_fd_sc_hd__mux2_1
X_4019_ _1767_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__clkbuf_1
X_2349_ _0404_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__buf_4
XFILLER_0_74_170 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_150 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_57_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold108 UART1.UART_TX1.index\[1\] VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__dlygate4sd3_1
X_3321_ RAM1.mem\[6\]\[3\] _1157_ _1115_ _1245_ VGND VGND VPWR VPWR _1246_ sky130_fd_sc_hd__o211a_1
X_4370_ clknet_leaf_8_clk _0149_ VGND VGND VPWR VPWR CPU1.alu_reg_out\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_156 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3252_ RAM1.mem\[12\]\[1\] RAM1.mem\[13\]\[1\] _1118_ VGND VGND VPWR VPWR _1179_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_21_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3183_ _2029_ net50 VGND VGND VPWR VPWR _1111_ sky130_fd_sc_hd__and2_1
XTAP_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_51 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2134_ _1934_ _1937_ VGND VGND VPWR VPWR _1938_ sky130_fd_sc_hd__nand2_1
X_2203_ UART1.UART_RX1.clkCount\[8\] _1960_ _1998_ _1999_ VGND VGND VPWR VPWR _2000_
+ sky130_fd_sc_hd__o22a_1
X_2967_ _2032_ _0898_ _0908_ _0909_ CPU1.ir_load VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__a221o_4
XFILLER_0_48_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2898_ CPU1.reg_a_out\[0\] _0847_ _0854_ _0858_ _0623_ VGND VGND VPWR VPWR _0122_
+ sky130_fd_sc_hd__o221a_1
X_4568_ clknet_leaf_7_clk _0345_ VGND VGND VPWR VPWR CPU1.reg_b_out\[1\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_71_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4499_ clknet_leaf_6_clk _0278_ VGND VGND VPWR VPWR RAM1.mem\[6\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_3519_ _0452_ _1415_ _1401_ VGND VGND VPWR VPWR _1416_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_20_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_20_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_85_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3870_ _1658_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__clkbuf_1
X_2821_ _0806_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_11_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_11_clk sky130_fd_sc_hd__clkbuf_16
X_4422_ clknet_leaf_11_clk _0201_ VGND VGND VPWR VPWR RAM1.mem\[1\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_53_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2752_ _0427_ _0742_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__or2_1
X_2683_ RAM1.mem\[8\]\[3\] RAM1.mem\[9\]\[3\] _0592_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__mux2_1
X_4353_ clknet_leaf_5_clk _0132_ VGND VGND VPWR VPWR CPU1.RF1.rf\[2\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_3235_ _1149_ _1153_ _1161_ _1162_ VGND VGND VPWR VPWR _1163_ sky130_fd_sc_hd__a31o_1
X_4284_ clknet_leaf_1_clk _0075_ VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__dfxtp_2
X_3304_ RAM1.mem\[18\]\[3\] RAM1.mem\[19\]\[3\] _1122_ VGND VGND VPWR VPWR _1229_
+ sky130_fd_sc_hd__mux2_1
XTAP_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3097_ net168 _0941_ _1037_ _0569_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__o211a_1
X_3166_ _1101_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__clkbuf_1
X_2117_ net21 _1921_ _1924_ net22 VGND VGND VPWR VPWR _1925_ sky130_fd_sc_hd__and4b_1
XFILLER_0_91_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3999_ _1753_ VGND VGND VPWR VPWR _1754_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_44_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3020_ _0953_ _0963_ _0894_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_25_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_0_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_0_clk sky130_fd_sc_hd__clkbuf_16
X_3784_ _0470_ RAM1.mem\[5\]\[2\] _1591_ VGND VGND VPWR VPWR _1598_ sky130_fd_sc_hd__mux2_1
X_3853_ _1646_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__clkbuf_1
X_2804_ _1927_ _0791_ _0792_ VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__or3_1
X_3922_ _1694_ _1688_ VGND VGND VPWR VPWR _1696_ sky130_fd_sc_hd__nand2_1
X_4405_ clknet_leaf_12_clk _0184_ VGND VGND VPWR VPWR RAM1.mem\[21\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_4336_ clknet_leaf_6_clk _0124_ VGND VGND VPWR VPWR CPU1.reg_a_out\[2\] sky130_fd_sc_hd__dfxtp_1
X_2735_ RAM1.mem\[6\]\[5\] _0586_ _0583_ RAM1.mem\[7\]\[5\] _0589_ VGND VGND VPWR
+ VPWR _0727_ sky130_fd_sc_hd__a221o_1
X_2666_ _0605_ _0658_ _0660_ _0599_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__o211a_1
XFILLER_0_81_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_262 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2597_ RAM1.mem\[12\]\[0\] RAM1.mem\[13\]\[0\] _0593_ VGND VGND VPWR VPWR _0594_
+ sky130_fd_sc_hd__mux2_1
X_4267_ clknet_leaf_13_clk _0058_ VGND VGND VPWR VPWR RAM1.mem\[22\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_3149_ _0956_ _1086_ VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__nand2_1
X_3218_ RAM1.mem\[15\]\[0\] _2076_ VGND VGND VPWR VPWR _1146_ sky130_fd_sc_hd__or2_1
X_4198_ _1872_ _1906_ _1874_ VGND VGND VPWR VPWR _1907_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_32_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_202 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2451_ _2075_ _2077_ _2039_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__or3b_1
X_2520_ net21 _0540_ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__or2_1
XFILLER_0_11_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4052_ _1790_ VGND VGND VPWR VPWR _1791_ sky130_fd_sc_hd__buf_2
X_2382_ _2104_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__buf_2
Xinput4 clk_per_bit[3] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_2
X_3003_ net173 _0945_ _0900_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__a21oi_1
X_4121_ UART1.UART_TX1.index\[2\] VGND VGND VPWR VPWR _1844_ sky130_fd_sc_hd__inv_2
XFILLER_0_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3905_ _1682_ _0404_ _1672_ VGND VGND VPWR VPWR _1683_ sky130_fd_sc_hd__mux2_1
X_3836_ RAM1.mem\[7\]\[1\] _2101_ _1630_ VGND VGND VPWR VPWR _1635_ sky130_fd_sc_hd__mux2_1
X_3767_ _0446_ _1585_ _1575_ VGND VGND VPWR VPWR _1586_ sky130_fd_sc_hd__mux2_1
XFILLER_0_52_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2718_ RAM1.mem\[18\]\[4\] RAM1.mem\[19\]\[4\] _0612_ VGND VGND VPWR VPWR _0711_
+ sky130_fd_sc_hd__mux2_1
X_4319_ clknet_leaf_5_clk _0107_ VGND VGND VPWR VPWR CPU1.RF1.rf\[3\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_3698_ _0443_ _1541_ _1533_ VGND VGND VPWR VPWR _1542_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2649_ _2092_ _0640_ _0644_ _0430_ VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__o211a_1
XFILLER_0_37_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3552_ _1439_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_238 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3621_ _1487_ _0405_ _1477_ VGND VGND VPWR VPWR _1488_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_235 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_3_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2503_ _0529_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__clkbuf_1
X_2365_ _0418_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__clkbuf_1
X_3483_ _1390_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2434_ _0475_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_102 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2296_ _2073_ _2080_ VGND VGND VPWR VPWR _2081_ sky130_fd_sc_hd__nand2_4
XFILLER_0_47_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4035_ _1779_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__clkbuf_1
X_4104_ _1832_ _2110_ _1828_ VGND VGND VPWR VPWR _1833_ sky130_fd_sc_hd__mux2_1
XFILLER_0_63_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3819_ _0443_ _1622_ _1614_ VGND VGND VPWR VPWR _1623_ sky130_fd_sc_hd__mux2_1
XFILLER_0_84_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_208 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2150_ UART1.RX_done uart_curr_state\[2\] VGND VGND VPWR VPWR _1950_ sky130_fd_sc_hd__or2b_1
X_2983_ _0894_ _0920_ _0927_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_48_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3535_ _0396_ RAM1.mem\[20\]\[4\] _1417_ VGND VGND VPWR VPWR _1427_ sky130_fd_sc_hd__mux2_1
X_4584_ clknet_leaf_0_clk _0361_ VGND VGND VPWR VPWR UART1.TX_done sky130_fd_sc_hd__dfxtp_1
X_3604_ _2067_ RAM1.mem\[17\]\[0\] _1475_ VGND VGND VPWR VPWR _1476_ sky130_fd_sc_hd__mux2_1
X_3397_ RAM1.mem\[8\]\[6\] _1144_ _1139_ _1318_ VGND VGND VPWR VPWR _1319_ sky130_fd_sc_hd__o211a_1
X_3466_ _2073_ _1377_ VGND VGND VPWR VPWR _1378_ sky130_fd_sc_hd__nand2_4
XFILLER_0_42_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2417_ _0457_ _0461_ VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__nor2_4
X_2348_ net34 _1941_ _2086_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__and3_4
X_2279_ _2064_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__clkbuf_1
X_4018_ _0411_ _1766_ _1754_ VGND VGND VPWR VPWR _1767_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold109 UART1.UART_TX1.clkCount\[5\] VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__dlygate4sd3_1
X_3320_ RAM1.mem\[7\]\[3\] _2074_ VGND VGND VPWR VPWR _1245_ sky130_fd_sc_hd__or2_1
X_3182_ _1110_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__clkbuf_1
XTAP_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2202_ UART1.UART_RX1.clkCount\[7\] _1979_ VGND VGND VPWR VPWR _1999_ sky130_fd_sc_hd__and2_1
X_3251_ _1134_ _1175_ _1177_ _1125_ VGND VGND VPWR VPWR _1178_ sky130_fd_sc_hd__a211o_1
XFILLER_0_44_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2133_ _1931_ uart_curr_state\[4\] VGND VGND VPWR VPWR _1937_ sky130_fd_sc_hd__nand2_4
X_2897_ _0852_ _2056_ _0855_ _0857_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__a31o_1
X_2966_ _0906_ _0907_ net49 VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__mux2_1
X_4498_ clknet_leaf_7_clk _0277_ VGND VGND VPWR VPWR RAM1.mem\[6\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_4567_ clknet_leaf_7_clk _0344_ VGND VGND VPWR VPWR CPU1.reg_b_out\[0\] sky130_fd_sc_hd__dfxtp_2
X_3518_ _0414_ RAM1.mem\[21\]\[7\] _1398_ VGND VGND VPWR VPWR _1415_ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3449_ _1365_ _1194_ VGND VGND VPWR VPWR _1368_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2751_ RAM1.mem\[8\]\[6\] RAM1.mem\[9\]\[6\] _0493_ VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__mux2_1
X_2820_ _0804_ _0805_ _0799_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__and3b_1
XFILLER_0_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4352_ clknet_leaf_5_clk _0131_ VGND VGND VPWR VPWR CPU1.RF1.rf\[2\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_100_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4421_ clknet_leaf_11_clk _0200_ VGND VGND VPWR VPWR RAM1.mem\[1\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_5_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2682_ RAM1.mem\[12\]\[3\] RAM1.mem\[13\]\[3\] _0612_ VGND VGND VPWR VPWR _0676_
+ sky130_fd_sc_hd__mux2_1
X_3234_ _2061_ CPU1.PC1.pc_out\[4\] _2065_ CPU1.reg_b_out\[4\] VGND VGND VPWR VPWR
+ _1162_ sky130_fd_sc_hd__a22o_4
XFILLER_0_55_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3165_ _1946_ _1100_ VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__and2_1
X_3303_ RAM1.mem\[16\]\[3\] RAM1.mem\[17\]\[3\] _1119_ VGND VGND VPWR VPWR _1228_
+ sky130_fd_sc_hd__mux2_1
X_4283_ clknet_leaf_1_clk _0074_ VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__dfxtp_4
XTAP_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3096_ net17 _0936_ _1036_ _0905_ _0937_ VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__a221o_1
X_2116_ net26 net25 _1920_ VGND VGND VPWR VPWR _1924_ sky130_fd_sc_hd__and3_1
XFILLER_0_91_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2949_ _0893_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__buf_2
XFILLER_0_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3998_ _0464_ _1671_ VGND VGND VPWR VPWR _1753_ sky130_fd_sc_hd__or2_1
XFILLER_0_90_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3921_ UART1.UART_RX1.index\[1\] UART1.UART_RX1.index\[0\] VGND VGND VPWR VPWR _1695_
+ sky130_fd_sc_hd__or2_1
X_3783_ _1597_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__clkbuf_1
X_2734_ RAM1.mem\[2\]\[5\] _0582_ _0497_ RAM1.mem\[3\]\[5\] _0584_ VGND VGND VPWR
+ VPWR _0726_ sky130_fd_sc_hd__a221o_1
XFILLER_0_73_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3852_ _0449_ _1645_ _1633_ VGND VGND VPWR VPWR _1646_ sky130_fd_sc_hd__mux2_1
X_2803_ net26 net25 net24 net23 VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__or4b_1
X_4404_ clknet_leaf_12_clk _0183_ VGND VGND VPWR VPWR RAM1.mem\[21\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_4335_ clknet_leaf_6_clk _0123_ VGND VGND VPWR VPWR CPU1.reg_a_out\[1\] sky130_fd_sc_hd__dfxtp_1
X_2596_ _0592_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__buf_4
X_2665_ _0427_ _0659_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__or2_1
XFILLER_0_41_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_296 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4266_ clknet_leaf_13_clk _0057_ VGND VGND VPWR VPWR RAM1.mem\[22\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_3148_ _0913_ _1007_ _1051_ _0901_ VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__a211o_1
XFILLER_0_66_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3217_ _1115_ VGND VGND VPWR VPWR _1145_ sky130_fd_sc_hd__clkbuf_4
X_4197_ UART1.UART_TX1.clkCount\[8\] UART1.UART_TX1.clkCount\[7\] _1896_ VGND VGND
+ VPWR VPWR _1906_ sky130_fd_sc_hd__and3_1
X_3079_ _0961_ _1019_ VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__xor2_1
XFILLER_0_32_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_99_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2381_ _0433_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__clkbuf_1
X_2450_ _0487_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4051_ CPU1.instr_reg_out\[4\] CPU1.curr_state\[2\] VGND VGND VPWR VPWR _1790_ sky130_fd_sc_hd__nand2_2
X_3002_ _0912_ _0899_ _0945_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__and3_1
X_4120_ _1843_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__clkbuf_1
Xinput5 clk_per_bit[4] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_2
X_3904_ RAM1.mem\[15\]\[5\] _0479_ _1669_ VGND VGND VPWR VPWR _1682_ sky130_fd_sc_hd__mux2_1
X_3766_ _0402_ RAM1.mem\[4\]\[5\] _1572_ VGND VGND VPWR VPWR _1585_ sky130_fd_sc_hd__mux2_1
X_3697_ RAM1.mem\[2\]\[4\] _0476_ _1530_ VGND VGND VPWR VPWR _1541_ sky130_fd_sc_hd__mux2_1
X_3835_ _1634_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2717_ RAM1.mem\[16\]\[4\] RAM1.mem\[17\]\[4\] _0612_ VGND VGND VPWR VPWR _0710_
+ sky130_fd_sc_hd__mux2_1
X_4318_ clknet_leaf_5_clk _0106_ VGND VGND VPWR VPWR CPU1.RF1.rf\[3\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2648_ _0615_ _0643_ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__or2_1
X_2579_ CPU1.PC1.pc_out\[0\] _1926_ _0575_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__a21bo_1
X_4249_ clknet_leaf_21_clk _0044_ VGND VGND VPWR VPWR RAM1.mem\[10\]\[6\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2502_ _0437_ _0528_ _0524_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__mux2_1
X_3551_ _0419_ _1436_ _1438_ VGND VGND VPWR VPWR _1439_ sky130_fd_sc_hd__mux2_1
X_3620_ _0402_ RAM1.mem\[17\]\[5\] _1475_ VGND VGND VPWR VPWR _1487_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2364_ _0415_ _0417_ _2099_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__mux2_1
X_3482_ _1389_ _0399_ _1381_ VGND VGND VPWR VPWR _1390_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2433_ _0474_ _0393_ _0465_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__mux2_1
X_4103_ _2108_ RAM1.mem\[12\]\[2\] _1826_ VGND VGND VPWR VPWR _1832_ sky130_fd_sc_hd__mux2_1
XFILLER_0_78_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2295_ _2079_ VGND VGND VPWR VPWR _2080_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_2_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4034_ _0387_ _1778_ _1774_ VGND VGND VPWR VPWR _1779_ sky130_fd_sc_hd__mux2_1
X_3818_ RAM1.mem\[6\]\[4\] _0395_ _1611_ VGND VGND VPWR VPWR _1622_ sky130_fd_sc_hd__mux2_1
XPHY_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3749_ _2067_ RAM1.mem\[4\]\[0\] _1572_ VGND VGND VPWR VPWR _1573_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2982_ _0921_ _0925_ _0926_ _0915_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__o22a_1
XFILLER_0_33_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3534_ _1426_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__clkbuf_1
X_3465_ _1376_ VGND VGND VPWR VPWR _1377_ sky130_fd_sc_hd__clkbuf_8
X_3603_ _1377_ _1474_ VGND VGND VPWR VPWR _1475_ sky130_fd_sc_hd__nand2_4
X_4583_ clknet_leaf_2_clk _0360_ VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_24_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2278_ _2062_ _2063_ VGND VGND VPWR VPWR _2064_ sky130_fd_sc_hd__and2_1
X_2416_ _0460_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__buf_6
XFILLER_0_58_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3396_ RAM1.mem\[9\]\[6\] _2076_ VGND VGND VPWR VPWR _1318_ sky130_fd_sc_hd__or2_1
X_2347_ _0402_ RAM1.mem\[8\]\[5\] _2081_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__mux2_1
XFILLER_0_66_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4017_ RAM1.mem\[14\]\[6\] _0407_ _1751_ VGND VGND VPWR VPWR _1766_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3181_ _1946_ _1109_ VGND VGND VPWR VPWR _1110_ sky130_fd_sc_hd__and2_1
XTAP_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2201_ UART1.UART_RX1.clkCount\[6\] _1977_ _1979_ UART1.UART_RX1.clkCount\[7\] _1997_
+ VGND VGND VPWR VPWR _1998_ sky130_fd_sc_hd__o221a_1
X_3250_ RAM1.mem\[8\]\[1\] _1138_ _1139_ _1176_ VGND VGND VPWR VPWR _1177_ sky130_fd_sc_hd__o211a_1
X_2132_ _1931_ uart_curr_state\[6\] VGND VGND VPWR VPWR _1936_ sky130_fd_sc_hd__and2b_1
XFILLER_0_88_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2896_ _0856_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__buf_2
X_2965_ _2032_ _0898_ _0908_ _0909_ CPU1.ir_load VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__a221oi_4
XFILLER_0_60_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3517_ _1414_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__clkbuf_1
X_4497_ clknet_leaf_7_clk _0276_ VGND VGND VPWR VPWR RAM1.mem\[6\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_3448_ _1365_ _2031_ _1366_ _1367_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__o211a_1
X_4566_ clknet_leaf_16_clk _0343_ VGND VGND VPWR VPWR RAM1.mem\[13\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3379_ RAM1.mem\[6\]\[5\] _0459_ _1115_ _1301_ VGND VGND VPWR VPWR _1302_ sky130_fd_sc_hd__o211a_1
XFILLER_0_85_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_256 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_53_131 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2750_ RAM1.mem\[12\]\[6\] RAM1.mem\[13\]\[6\] _0494_ VGND VGND VPWR VPWR _0741_
+ sky130_fd_sc_hd__mux2_1
X_2681_ RAM1.mem\[14\]\[3\] _0586_ _0583_ RAM1.mem\[15\]\[3\] _0605_ VGND VGND VPWR
+ VPWR _0675_ sky130_fd_sc_hd__a221o_1
XFILLER_0_30_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4420_ clknet_leaf_11_clk _0199_ VGND VGND VPWR VPWR RAM1.mem\[1\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_4351_ clknet_leaf_5_clk _0130_ VGND VGND VPWR VPWR CPU1.RF1.rf\[2\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_3302_ _1134_ _1224_ _1226_ _1125_ VGND VGND VPWR VPWR _1227_ sky130_fd_sc_hd__o211a_1
X_4282_ clknet_leaf_1_clk _0073_ VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__dfxtp_4
XFILLER_0_30_88 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3233_ _1154_ _1156_ _1160_ _1131_ VGND VGND VPWR VPWR _1161_ sky130_fd_sc_hd__a211o_1
X_3095_ _1035_ VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__inv_2
X_3164_ CPU1.alu_reg_out\[7\] _1090_ _1094_ VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__mux2_1
X_2115_ _1920_ _1921_ _1922_ VGND VGND VPWR VPWR _1923_ sky130_fd_sc_hd__and3_2
XTAP_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_71_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3997_ RAM1.mem\[14\]\[0\] _2066_ _1751_ VGND VGND VPWR VPWR _1752_ sky130_fd_sc_hd__mux2_1
X_2879_ _0836_ _0842_ _0843_ net103 VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__a22o_1
X_2948_ _0892_ _2041_ _2028_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__and3b_1
XFILLER_0_44_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4549_ clknet_leaf_26_clk _0326_ VGND VGND VPWR VPWR UART1.UART_RX1.dataOut\[6\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_67_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3851_ RAM1.mem\[7\]\[6\] _0407_ _1630_ VGND VGND VPWR VPWR _1645_ sky130_fd_sc_hd__mux2_1
X_3920_ UART1.UART_RX1.index\[1\] VGND VGND VPWR VPWR _1694_ sky130_fd_sc_hd__clkbuf_2
X_3782_ _0434_ _1596_ _1594_ VGND VGND VPWR VPWR _1597_ sky130_fd_sc_hd__mux2_1
X_2664_ RAM1.mem\[0\]\[2\] RAM1.mem\[1\]\[2\] _0596_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_41_76 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2802_ net22 net21 _1941_ VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__nand3_1
X_2733_ _0580_ _0719_ _0720_ _0724_ _2093_ VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__a311o_1
XFILLER_0_14_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4403_ clknet_leaf_12_clk _0182_ VGND VGND VPWR VPWR RAM1.mem\[21\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_4334_ clknet_leaf_6_clk _0122_ VGND VGND VPWR VPWR CPU1.reg_a_out\[0\] sky130_fd_sc_hd__dfxtp_1
X_4265_ clknet_leaf_13_clk _0056_ VGND VGND VPWR VPWR RAM1.mem\[22\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_2595_ _0493_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__buf_4
XFILLER_0_5_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3078_ _1017_ net48 VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__xor2_2
X_3147_ _1029_ _1078_ _0921_ VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__o21ai_1
X_3216_ _1137_ VGND VGND VPWR VPWR _1144_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_49_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4196_ UART1.UART_TX1.clkCount\[7\] _1904_ _1896_ UART1.UART_TX1.clkCount\[8\] VGND
+ VGND VPWR VPWR _1905_ sky130_fd_sc_hd__a31o_1
XFILLER_0_99_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2380_ _0419_ _0424_ _0432_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__mux2_1
XFILLER_0_78_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3001_ _0944_ VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__buf_2
X_4050_ _1789_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__clkbuf_1
Xinput6 clk_per_bit[5] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_1
X_3834_ _0419_ _1631_ _1633_ VGND VGND VPWR VPWR _1634_ sky130_fd_sc_hd__mux2_1
X_3903_ _1681_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__clkbuf_1
X_3765_ _1584_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__clkbuf_1
X_3696_ _1540_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__clkbuf_1
X_2716_ _0579_ _0703_ _0704_ _0708_ _0426_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__a311o_1
XFILLER_0_65_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2647_ _0641_ _0642_ _0578_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__mux2_1
X_4317_ clknet_leaf_5_clk _0105_ VGND VGND VPWR VPWR CPU1.RF1.rf\[3\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_2578_ _0574_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__buf_2
X_4248_ clknet_leaf_21_clk _0043_ VGND VGND VPWR VPWR RAM1.mem\[10\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_4179_ _2058_ _1891_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__nor2_1
XFILLER_0_45_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2501_ RAM1.mem\[22\]\[2\] _0470_ _0519_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__mux2_1
X_3550_ _1437_ VGND VGND VPWR VPWR _1438_ sky130_fd_sc_hd__clkbuf_4
X_3481_ _0396_ RAM1.mem\[9\]\[4\] _1378_ VGND VGND VPWR VPWR _1389_ sky130_fd_sc_hd__mux2_1
XFILLER_0_22_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2363_ _0416_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__clkbuf_4
X_2294_ _2039_ _2076_ _2078_ VGND VGND VPWR VPWR _2079_ sky130_fd_sc_hd__and3_1
X_4033_ _0470_ RAM1.mem\[13\]\[2\] _1771_ VGND VGND VPWR VPWR _1778_ sky130_fd_sc_hd__mux2_1
X_2432_ RAM1.mem\[10\]\[3\] _0473_ _0462_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__mux2_1
X_4102_ _1831_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3817_ _1621_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__clkbuf_1
X_3748_ _2080_ _1571_ VGND VGND VPWR VPWR _1572_ sky130_fd_sc_hd__nand2_4
XFILLER_0_19_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3679_ _1527_ _0416_ _1513_ VGND VGND VPWR VPWR _1528_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3602_ _1190_ _1162_ _1149_ VGND VGND VPWR VPWR _1474_ sky130_fd_sc_hd__and3_2
X_2981_ _0913_ _0914_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2415_ _2077_ _0459_ _2039_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__or3b_1
X_3464_ _2039_ _1137_ _2078_ VGND VGND VPWR VPWR _1376_ sky130_fd_sc_hd__and3_1
X_3533_ _1425_ _0393_ _1419_ VGND VGND VPWR VPWR _1426_ sky130_fd_sc_hd__mux2_1
X_4582_ clknet_leaf_16_clk _0359_ VGND VGND VPWR VPWR RAM1.mem\[12\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_24_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2346_ _0401_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__buf_4
XFILLER_0_58_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4016_ _1765_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__clkbuf_1
X_3395_ RAM1.mem\[10\]\[6\] RAM1.mem\[11\]\[6\] _1135_ VGND VGND VPWR VPWR _1317_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2277_ _1939_ VGND VGND VPWR VPWR _2063_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_99_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_23_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_23_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_79_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3180_ CPU1.alu_reg_out\[6\] _1075_ _0903_ VGND VGND VPWR VPWR _1109_ sky130_fd_sc_hd__mux2_1
XTAP_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2131_ _1935_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2200_ UART1.UART_RX1.clkCount\[5\] _1973_ _1977_ UART1.UART_RX1.clkCount\[6\] _1996_
+ VGND VGND VPWR VPWR _1997_ sky130_fd_sc_hd__a221o_1
X_2964_ CPU1.reg_b_out\[0\] _2051_ _2028_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__o21a_1
XFILLER_0_44_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2895_ _2029_ _2059_ CPU1.curr_state\[2\] VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__a21oi_4
Xclkbuf_leaf_14_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_14_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_60_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4565_ clknet_leaf_20_clk _0342_ VGND VGND VPWR VPWR RAM1.mem\[13\]\[6\] sky130_fd_sc_hd__dfxtp_2
X_3516_ _0449_ _1413_ _1401_ VGND VGND VPWR VPWR _1414_ sky130_fd_sc_hd__mux2_1
X_3378_ RAM1.mem\[7\]\[5\] _2074_ VGND VGND VPWR VPWR _1301_ sky130_fd_sc_hd__or2_1
X_4496_ clknet_leaf_8_clk _0275_ VGND VGND VPWR VPWR RAM1.mem\[6\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_3447_ _1365_ _1165_ VGND VGND VPWR VPWR _1367_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2329_ _2109_ _0387_ _2099_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_143 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2680_ RAM1.mem\[10\]\[3\] _0582_ _0497_ RAM1.mem\[11\]\[3\] _0428_ VGND VGND VPWR
+ VPWR _0674_ sky130_fd_sc_hd__a221o_1
X_4350_ clknet_leaf_4_clk _0005_ VGND VGND VPWR VPWR CPU1.curr_state\[5\] sky130_fd_sc_hd__dfxtp_1
X_3232_ RAM1.mem\[6\]\[0\] _1157_ _1115_ _1159_ VGND VGND VPWR VPWR _1160_ sky130_fd_sc_hd__o211a_1
X_3301_ _1121_ _1225_ VGND VGND VPWR VPWR _1226_ sky130_fd_sc_hd__or2_1
Xclkbuf_leaf_3_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_3_clk sky130_fd_sc_hd__clkbuf_16
X_4281_ clknet_leaf_1_clk _0072_ VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__dfxtp_2
XTAP_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3094_ _0924_ _1023_ _1026_ _1034_ VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__a211oi_4
X_3163_ _1095_ _1099_ _1952_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__a21oi_1
X_2114_ net25 net22 net21 net26 VGND VGND VPWR VPWR _1922_ sky130_fd_sc_hd__and4b_1
XTAP_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3996_ _0461_ _1668_ VGND VGND VPWR VPWR _1751_ sky130_fd_sc_hd__nor2_4
X_2947_ _2030_ _2043_ _0891_ _2042_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__o211a_1
XFILLER_0_17_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2878_ _0835_ _0842_ _0843_ net91 VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__a22o_1
XFILLER_0_44_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4548_ clknet_leaf_26_clk _0325_ VGND VGND VPWR VPWR UART1.UART_RX1.dataOut\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_96_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4479_ clknet_leaf_9_clk _0258_ VGND VGND VPWR VPWR RAM1.mem\[3\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_82_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3850_ _1644_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__clkbuf_1
X_3781_ _0467_ RAM1.mem\[5\]\[1\] _1591_ VGND VGND VPWR VPWR _1596_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2801_ net158 _0575_ _0790_ _0569_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__o211a_1
X_4402_ clknet_leaf_12_clk _0181_ VGND VGND VPWR VPWR RAM1.mem\[21\]\[2\] sky130_fd_sc_hd__dfxtp_2
X_2663_ RAM1.mem\[4\]\[2\] RAM1.mem\[5\]\[2\] _0593_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__mux2_1
X_2594_ _0588_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_41_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2732_ _0591_ _0721_ _0723_ _0600_ VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__o211a_1
XFILLER_0_1_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4264_ clknet_leaf_13_clk _0055_ VGND VGND VPWR VPWR RAM1.mem\[22\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_4333_ clknet_leaf_1_clk _0121_ VGND VGND VPWR VPWR step_pulse sky130_fd_sc_hd__dfxtp_1
X_3215_ RAM1.mem\[12\]\[0\] RAM1.mem\[13\]\[0\] _1118_ VGND VGND VPWR VPWR _1143_
+ sky130_fd_sc_hd__mux2_1
X_4195_ _1872_ VGND VGND VPWR VPWR _1904_ sky130_fd_sc_hd__inv_2
X_3146_ _0922_ _0894_ _0915_ VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__a21oi_1
X_3077_ _0912_ _0900_ _0969_ _0993_ _0945_ VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__o41ai_1
XFILLER_0_49_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3979_ _1720_ _1737_ net134 VGND VGND VPWR VPWR _1738_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput7 clk_per_bit[6] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_4
X_3000_ _2037_ _0943_ _0892_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__or3_1
XFILLER_0_52_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3764_ _0443_ _1583_ _1575_ VGND VGND VPWR VPWR _1584_ sky130_fd_sc_hd__mux2_1
X_3833_ _1632_ VGND VGND VPWR VPWR _1633_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_46_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3902_ _1680_ _0398_ _1672_ VGND VGND VPWR VPWR _1681_ sky130_fd_sc_hd__mux2_1
X_3695_ _0440_ _1539_ _1533_ VGND VGND VPWR VPWR _1540_ sky130_fd_sc_hd__mux2_1
X_2715_ _0605_ _0705_ _0707_ _0599_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__o211a_1
XFILLER_0_58_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2646_ RAM1.mem\[22\]\[1\] RAM1.mem\[23\]\[1\] _0495_ VGND VGND VPWR VPWR _0642_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2577_ _1919_ _1934_ _0573_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__and3_1
XFILLER_0_93_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4178_ _1873_ _1888_ _1889_ _1874_ _1890_ VGND VGND VPWR VPWR _1891_ sky130_fd_sc_hd__o32a_1
X_4316_ clknet_leaf_24_clk _0104_ VGND VGND VPWR VPWR UART1.UART_RX1.clkCount\[9\]
+ sky130_fd_sc_hd__dfxtp_1
X_4247_ clknet_leaf_23_clk _0042_ VGND VGND VPWR VPWR RAM1.mem\[10\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_96_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3129_ _1064_ _1067_ VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_60_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2500_ _0527_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__clkbuf_1
X_2431_ _0389_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__clkbuf_8
X_3480_ _1388_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__clkbuf_1
X_2293_ _2077_ VGND VGND VPWR VPWR _2078_ sky130_fd_sc_hd__buf_2
XFILLER_0_47_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_10 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2362_ net36 _1919_ _2086_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__and3_2
X_4032_ _1777_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__clkbuf_1
X_4101_ _1830_ _2104_ _1828_ VGND VGND VPWR VPWR _1831_ sky130_fd_sc_hd__mux2_1
XFILLER_0_86_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3816_ _0440_ _1620_ _1614_ VGND VGND VPWR VPWR _1621_ sky130_fd_sc_hd__mux2_1
X_3747_ _1131_ _0421_ VGND VGND VPWR VPWR _1571_ sky130_fd_sc_hd__nor2_2
XFILLER_0_100_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3678_ RAM1.mem\[23\]\[7\] _0485_ _1511_ VGND VGND VPWR VPWR _1527_ sky130_fd_sc_hd__mux2_1
X_2629_ RAM1.mem\[14\]\[1\] _0582_ _0583_ RAM1.mem\[15\]\[1\] _0605_ VGND VGND VPWR
+ VPWR _0625_ sky130_fd_sc_hd__a221o_1
XFILLER_0_92_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2980_ _0915_ _0922_ _0924_ _0913_ _0914_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__o32a_1
XFILLER_0_17_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput10 clk_per_bit[9] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_2
X_3601_ _1473_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__clkbuf_1
X_4581_ clknet_leaf_21_clk _0358_ VGND VGND VPWR VPWR RAM1.mem\[12\]\[6\] sky130_fd_sc_hd__dfxtp_2
X_3463_ _0852_ _1365_ _1366_ _1375_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__o211a_1
X_3532_ _0390_ RAM1.mem\[20\]\[3\] _1417_ VGND VGND VPWR VPWR _1425_ sky130_fd_sc_hd__mux2_1
X_2414_ _0458_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__clkbuf_4
X_3394_ _1117_ _1313_ _1315_ _1132_ VGND VGND VPWR VPWR _1316_ sky130_fd_sc_hd__o211a_1
X_2345_ _2049_ CPU1.reg_a_out\[5\] _2065_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__and3_2
X_4015_ _0405_ _1764_ _1754_ VGND VGND VPWR VPWR _1765_ sky130_fd_sc_hd__mux2_1
X_2276_ _2061_ VGND VGND VPWR VPWR _2062_ sky130_fd_sc_hd__buf_2
XFILLER_0_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2130_ _0008_ _0007_ _0019_ VGND VGND VPWR VPWR _1935_ sky130_fd_sc_hd__or3_1
X_2963_ CPU1.instr_reg_out\[4\] _2036_ _2041_ _2032_ _2044_ VGND VGND VPWR VPWR _0908_
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3515_ _0408_ RAM1.mem\[21\]\[6\] _1398_ VGND VGND VPWR VPWR _1413_ sky130_fd_sc_hd__mux2_1
X_2894_ CPU1.RF1.rf\[3\]\[0\] CPU1.RF1.rf\[2\]\[0\] _0849_ VGND VGND VPWR VPWR _0855_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4564_ clknet_leaf_22_clk _0341_ VGND VGND VPWR VPWR RAM1.mem\[13\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_3377_ RAM1.mem\[4\]\[5\] RAM1.mem\[5\]\[5\] _1155_ VGND VGND VPWR VPWR _1300_ sky130_fd_sc_hd__mux2_1
X_4495_ clknet_leaf_15_clk _0274_ VGND VGND VPWR VPWR RAM1.mem\[5\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_3446_ _1939_ VGND VGND VPWR VPWR _1366_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2328_ _2110_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__buf_4
X_2259_ _2049_ _2031_ VGND VGND VPWR VPWR _2050_ sky130_fd_sc_hd__and2_1
XFILLER_0_94_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3231_ RAM1.mem\[7\]\[0\] _1158_ VGND VGND VPWR VPWR _1159_ sky130_fd_sc_hd__or2_1
X_3300_ RAM1.mem\[22\]\[3\] RAM1.mem\[23\]\[3\] _1137_ VGND VGND VPWR VPWR _1225_
+ sky130_fd_sc_hd__mux2_1
X_3162_ _1055_ _1075_ _1090_ _1098_ VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__or4b_4
XFILLER_0_39_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4280_ clknet_leaf_0_clk _0071_ VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__dfxtp_4
XTAP_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3093_ _0921_ _1027_ _1028_ _0915_ _1033_ VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__a221o_1
X_2113_ net27 net28 VGND VGND VPWR VPWR _1921_ sky130_fd_sc_hd__and2b_1
X_2877_ _0834_ _0842_ _0843_ net102 VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__a22o_1
X_2946_ CPU1.instr_reg_out\[5\] _2033_ _2040_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__or3_1
XFILLER_0_29_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3995_ net124 _1720_ _1750_ _1308_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__o211a_1
XFILLER_0_88_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4478_ clknet_leaf_8_clk _0257_ VGND VGND VPWR VPWR RAM1.mem\[3\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4547_ clknet_leaf_26_clk _0324_ VGND VGND VPWR VPWR UART1.UART_RX1.dataOut\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3429_ RAM1.mem\[15\]\[7\] _2075_ VGND VGND VPWR VPWR _1350_ sky130_fd_sc_hd__or2_1
XFILLER_0_90_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3780_ _1595_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__clkbuf_1
X_2800_ CPU1.PC1.pc_out\[7\] _1926_ _0789_ _1923_ _0647_ VGND VGND VPWR VPWR _0790_
+ sky130_fd_sc_hd__a221o_1
X_2731_ _0595_ _0722_ VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__or2_1
X_4332_ clknet_leaf_6_clk _0120_ VGND VGND VPWR VPWR CPU1.RF1.rf\[1\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_4401_ clknet_leaf_13_clk _0180_ VGND VGND VPWR VPWR RAM1.mem\[21\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_2662_ RAM1.mem\[6\]\[2\] _0581_ _0587_ RAM1.mem\[7\]\[2\] _0589_ VGND VGND VPWR
+ VPWR _0657_ sky130_fd_sc_hd__a221o_1
XFILLER_0_81_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2593_ RAM1.mem\[14\]\[0\] _0586_ _0587_ RAM1.mem\[15\]\[0\] _0589_ VGND VGND VPWR
+ VPWR _0590_ sky130_fd_sc_hd__a221o_1
XFILLER_0_1_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3145_ _1077_ _1081_ _0943_ VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__a21o_1
X_4263_ clknet_leaf_13_clk _0054_ VGND VGND VPWR VPWR RAM1.mem\[22\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_4194_ _1952_ _1903_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__nor2_1
X_3214_ _1134_ _1136_ _1141_ _1125_ VGND VGND VPWR VPWR _1142_ sky130_fd_sc_hd__a211o_1
XFILLER_0_82_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3076_ _2028_ _0991_ _1016_ _0898_ CPU1.instr_reg_out\[7\] VGND VGND VPWR VPWR _1017_
+ sky130_fd_sc_hd__a32o_2
XFILLER_0_49_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2929_ net153 _0847_ _0881_ _0883_ _0879_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__o221a_1
XFILLER_0_72_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3978_ UART1.UART_RX1.index\[2\] _1727_ UART1.UART_RX1.state\[1\] VGND VGND VPWR
+ VPWR _1737_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_17_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput8 clk_per_bit[7] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_2
X_3901_ RAM1.mem\[15\]\[4\] _0476_ _1669_ VGND VGND VPWR VPWR _1680_ sky130_fd_sc_hd__mux2_1
X_3763_ _0396_ RAM1.mem\[4\]\[4\] _1572_ VGND VGND VPWR VPWR _1583_ sky130_fd_sc_hd__mux2_1
X_3694_ RAM1.mem\[2\]\[3\] _0473_ _1530_ VGND VGND VPWR VPWR _1539_ sky130_fd_sc_hd__mux2_1
X_2714_ _0427_ _0706_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__or2_1
X_3832_ _0425_ _0615_ _0429_ _0498_ VGND VGND VPWR VPWR _1632_ sky130_fd_sc_hd__or4_1
XFILLER_0_54_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2645_ RAM1.mem\[20\]\[1\] RAM1.mem\[21\]\[1\] _0495_ VGND VGND VPWR VPWR _0641_
+ sky130_fd_sc_hd__mux2_1
X_2576_ _1930_ _0571_ _0572_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__a21oi_1
X_4315_ clknet_leaf_24_clk _0103_ VGND VGND VPWR VPWR UART1.UART_RX1.clkCount\[8\]
+ sky130_fd_sc_hd__dfxtp_1
X_3128_ _1000_ _0999_ _1020_ _1044_ _1066_ VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__a41o_1
X_4177_ UART1.UART_TX1.clkCount\[4\] VGND VGND VPWR VPWR _1890_ sky130_fd_sc_hd__inv_2
X_4246_ clknet_leaf_21_clk _0041_ VGND VGND VPWR VPWR RAM1.mem\[10\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_3059_ _0906_ _0995_ VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__nand2_1
XFILLER_0_60_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_22 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2361_ _0414_ RAM1.mem\[8\]\[7\] _2081_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__mux2_1
X_2430_ _0472_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__clkbuf_1
X_2292_ _2061_ CPU1.PC1.pc_out\[1\] net53 CPU1.reg_b_out\[1\] VGND VGND VPWR VPWR
+ _2077_ sky130_fd_sc_hd__a22oi_4
X_4031_ _2105_ _1776_ _1774_ VGND VGND VPWR VPWR _1777_ sky130_fd_sc_hd__mux2_1
X_4100_ _2102_ RAM1.mem\[12\]\[1\] _1826_ VGND VGND VPWR VPWR _1830_ sky130_fd_sc_hd__mux2_1
X_3815_ RAM1.mem\[6\]\[3\] _0389_ _1611_ VGND VGND VPWR VPWR _1620_ sky130_fd_sc_hd__mux2_1
X_3746_ _1570_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3677_ _1526_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2559_ net113 _1932_ _0562_ _0557_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__o211a_1
X_4229_ clknet_leaf_19_clk _0024_ VGND VGND VPWR VPWR RAM1.mem\[8\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_2628_ RAM1.mem\[10\]\[1\] _0582_ _0497_ RAM1.mem\[11\]\[1\] _0428_ VGND VGND VPWR
+ VPWR _0624_ sky130_fd_sc_hd__a221o_1
XFILLER_0_0_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3531_ _1424_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__clkbuf_1
X_4580_ clknet_leaf_22_clk _0357_ VGND VGND VPWR VPWR RAM1.mem\[12\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput11 rst VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_2
X_3600_ _1472_ _0417_ _1458_ VGND VGND VPWR VPWR _1473_ sky130_fd_sc_hd__mux2_1
XFILLER_0_24_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2413_ CPU1.ir_load CPU1.PC1.pc_out\[0\] net52 CPU1.reg_b_out\[0\] VGND VGND VPWR
+ VPWR _0458_ sky130_fd_sc_hd__a22o_4
X_3462_ _2062_ _1363_ VGND VGND VPWR VPWR _1375_ sky130_fd_sc_hd__nand2_1
X_3393_ _1121_ _1314_ VGND VGND VPWR VPWR _1315_ sky130_fd_sc_hd__or2_1
X_2344_ _0400_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_1_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_1_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4014_ RAM1.mem\[14\]\[5\] _0401_ _1751_ VGND VGND VPWR VPWR _1764_ sky130_fd_sc_hd__mux2_1
X_2275_ CPU1.ir_load VGND VGND VPWR VPWR _2061_ sky130_fd_sc_hd__buf_4
XFILLER_0_90_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3729_ RAM1.mem\[3\]\[2\] _2107_ _1552_ VGND VGND VPWR VPWR _1559_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2893_ CPU1.RF1.rf\[1\]\[0\] _0849_ _0851_ _0853_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__o211a_1
XFILLER_0_88_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2962_ CPU1.reg_a_out\[2\] _0903_ _0904_ CPU1.PC1.pc_out\[2\] VGND VGND VPWR VPWR
+ _0907_ sky130_fd_sc_hd__a22o_2
XFILLER_0_29_301 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_100_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3514_ _1412_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_69_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4494_ clknet_leaf_15_clk _0273_ VGND VGND VPWR VPWR RAM1.mem\[5\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_3445_ _2062_ VGND VGND VPWR VPWR _1365_ sky130_fd_sc_hd__clkbuf_4
X_4563_ clknet_leaf_22_clk _0340_ VGND VGND VPWR VPWR RAM1.mem\[13\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_3376_ _1145_ _1296_ _1298_ _0456_ VGND VGND VPWR VPWR _1299_ sky130_fd_sc_hd__a211o_1
X_2258_ CPU1.instr_reg_out\[1\] VGND VGND VPWR VPWR _2049_ sky130_fd_sc_hd__clkbuf_2
X_2327_ net31 _1941_ _2086_ VGND VGND VPWR VPWR _2110_ sky130_fd_sc_hd__and3_4
XFILLER_0_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2189_ _1939_ UART1.TX_en UART1.UART_TX1.state\[0\] VGND VGND VPWR VPWR _1988_ sky130_fd_sc_hd__and3_1
XFILLER_0_62_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_178 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3230_ _2074_ VGND VGND VPWR VPWR _1158_ sky130_fd_sc_hd__buf_2
X_3161_ _0988_ _1013_ _1035_ _1097_ VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__and4_1
X_2112_ net24 net23 VGND VGND VPWR VPWR _1920_ sky130_fd_sc_hd__nor2_1
XTAP_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3092_ _0953_ _1031_ _1032_ _0894_ VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__o211a_1
XFILLER_0_55_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2876_ _0833_ _0842_ _0843_ net100 VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__a22o_1
X_2945_ _2029_ _2036_ _2062_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_44_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3994_ _2005_ _1749_ _1719_ VGND VGND VPWR VPWR _1750_ sky130_fd_sc_hd__a21bo_1
X_4477_ clknet_leaf_11_clk _0256_ VGND VGND VPWR VPWR RAM1.mem\[3\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_3428_ RAM1.mem\[12\]\[7\] RAM1.mem\[13\]\[7\] _1118_ VGND VGND VPWR VPWR _1349_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4546_ clknet_leaf_26_clk _0323_ VGND VGND VPWR VPWR UART1.UART_RX1.dataOut\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3359_ _1154_ _1281_ VGND VGND VPWR VPWR _1282_ sky130_fd_sc_hd__or2_1
XFILLER_0_82_229 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2661_ RAM1.mem\[2\]\[2\] _0581_ _0587_ RAM1.mem\[3\]\[2\] _0584_ VGND VGND VPWR
+ VPWR _0656_ sky130_fd_sc_hd__a221o_1
X_2730_ RAM1.mem\[8\]\[5\] RAM1.mem\[9\]\[5\] _0592_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_178 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4331_ clknet_leaf_5_clk _0119_ VGND VGND VPWR VPWR CPU1.RF1.rf\[1\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_4400_ clknet_leaf_13_clk _0179_ VGND VGND VPWR VPWR RAM1.mem\[21\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_2592_ _0588_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_5_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4262_ clknet_leaf_25_clk _0015_ VGND VGND VPWR VPWR UART1.UART_RX1.state\[3\] sky130_fd_sc_hd__dfxtp_1
X_3144_ _1077_ _1081_ VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__nor2_1
X_3075_ CPU1.reg_b_out\[4\] _2051_ VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__or2_1
XFILLER_0_66_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4193_ _1873_ _1900_ _1901_ _1874_ _1902_ VGND VGND VPWR VPWR _1903_ sky130_fd_sc_hd__o32a_1
X_3213_ RAM1.mem\[8\]\[0\] _1138_ _1139_ _1140_ VGND VGND VPWR VPWR _1141_ sky130_fd_sc_hd__o211a_1
XFILLER_0_57_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3977_ net105 _1720_ _1736_ _1308_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__o211a_1
X_2928_ _0852_ _2056_ _0882_ _0857_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__a31o_1
X_2859_ net78 _0827_ _0829_ net69 VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__a22o_2
X_4529_ clknet_leaf_9_clk _0306_ VGND VGND VPWR VPWR RAM1.mem\[15\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput9 clk_per_bit[8] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_36_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3831_ RAM1.mem\[7\]\[0\] _2066_ _1630_ VGND VGND VPWR VPWR _1631_ sky130_fd_sc_hd__mux2_1
X_3900_ _1679_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__clkbuf_1
X_3762_ _1582_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__clkbuf_1
X_3693_ _1538_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__clkbuf_1
X_2713_ RAM1.mem\[0\]\[4\] RAM1.mem\[1\]\[4\] _0596_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2644_ _0638_ _0639_ _0579_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__mux2_1
XFILLER_0_39_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2575_ uart_curr_state\[4\] uart_curr_state\[2\] _1936_ _0385_ _1931_ VGND VGND VPWR
+ VPWR _0572_ sky130_fd_sc_hd__o32a_1
X_4314_ clknet_leaf_24_clk _0102_ VGND VGND VPWR VPWR UART1.UART_RX1.clkCount\[7\]
+ sky130_fd_sc_hd__dfxtp_1
X_4245_ clknet_leaf_23_clk _0040_ VGND VGND VPWR VPWR RAM1.mem\[10\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_3127_ _0972_ _1043_ _1065_ VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__o21a_1
X_3058_ _0906_ _0995_ VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__or2_1
X_4176_ UART1.UART_TX1.clkCount\[4\] _1885_ VGND VGND VPWR VPWR _1889_ sky130_fd_sc_hd__nor2_1
XFILLER_0_92_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_273 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2360_ _0413_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__clkbuf_4
X_2291_ _2075_ VGND VGND VPWR VPWR _2076_ sky130_fd_sc_hd__buf_2
XFILLER_0_47_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4030_ _0467_ RAM1.mem\[13\]\[1\] _1771_ VGND VGND VPWR VPWR _1776_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3814_ _1619_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_74_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_112 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3745_ _0452_ _1569_ _1555_ VGND VGND VPWR VPWR _1570_ sky130_fd_sc_hd__mux2_1
X_3676_ _1525_ _0410_ _1513_ VGND VGND VPWR VPWR _1526_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2627_ net39 _0575_ _0576_ _0622_ _0623_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__o221a_1
X_2489_ _0515_ _0516_ _0517_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__or3_2
X_2558_ net30 _0560_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__or2_1
X_4228_ clknet_leaf_19_clk _0023_ VGND VGND VPWR VPWR RAM1.mem\[8\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap49 _0910_ VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__clkbuf_2
X_4159_ _2058_ _1875_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__nor2_1
XFILLER_0_33_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_26_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_26_clk sky130_fd_sc_hd__clkbuf_16
Xinput12 uart_rx VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_1
X_3461_ _1365_ net163 _1366_ _1374_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__o211a_1
X_3530_ _1423_ _0387_ _1419_ VGND VGND VPWR VPWR _1424_ sky130_fd_sc_hd__mux2_1
X_4013_ _1763_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__clkbuf_1
X_2412_ _0456_ _2072_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__or2_4
X_2274_ _2058_ _2060_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__nor2_1
X_3392_ RAM1.mem\[18\]\[6\] RAM1.mem\[19\]\[6\] _1122_ VGND VGND VPWR VPWR _1314_
+ sky130_fd_sc_hd__mux2_1
X_2343_ _0397_ _0399_ _2099_ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_17_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_17_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_99_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3728_ _1558_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_100_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3659_ _1514_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_30_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2892_ _0852_ _2055_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__nand2_2
X_2961_ CPU1.reg_a_out\[3\] _0903_ _0905_ CPU1.PC1.pc_out\[3\] VGND VGND VPWR VPWR
+ _0906_ sky130_fd_sc_hd__a22o_2
XFILLER_0_60_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3513_ _0446_ _1411_ _1401_ VGND VGND VPWR VPWR _1412_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_6_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_6_clk sky130_fd_sc_hd__clkbuf_16
X_4493_ clknet_leaf_12_clk _0272_ VGND VGND VPWR VPWR RAM1.mem\[5\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_3444_ net75 _1113_ _1364_ _1308_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__o211a_1
X_4562_ clknet_leaf_20_clk _0339_ VGND VGND VPWR VPWR RAM1.mem\[13\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_3375_ RAM1.mem\[0\]\[5\] _1157_ _2077_ _1297_ VGND VGND VPWR VPWR _1298_ sky130_fd_sc_hd__o211a_1
XFILLER_0_85_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_20 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2257_ net141 net61 VGND VGND VPWR VPWR _2048_ sky130_fd_sc_hd__nor2_1
X_2326_ _2108_ RAM1.mem\[8\]\[2\] _2081_ VGND VGND VPWR VPWR _2109_ sky130_fd_sc_hd__mux2_1
XFILLER_0_94_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_290 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_79_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2188_ _1953_ _1986_ VGND VGND VPWR VPWR _1987_ sky130_fd_sc_hd__nand2_1
XFILLER_0_47_198 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_154 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_308 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3091_ _0953_ _0974_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__nand2_1
X_3160_ _0966_ _1096_ VGND VGND VPWR VPWR _1097_ sky130_fd_sc_hd__nor2_1
XFILLER_0_55_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2111_ uart_curr_state\[1\] VGND VGND VPWR VPWR _1919_ sky130_fd_sc_hd__buf_4
Xhold1 UART1.UART_RX1.regInMeta VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3993_ _1694_ _1688_ UART1.UART_RX1.regIn _1742_ _1748_ VGND VGND VPWR VPWR _1749_
+ sky130_fd_sc_hd__a41o_1
X_2944_ _0826_ _0838_ _0888_ _0889_ net84 VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__a32o_1
X_2875_ _0832_ _0842_ _0843_ net117 VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__a22o_1
X_4545_ clknet_leaf_26_clk _0322_ VGND VGND VPWR VPWR UART1.UART_RX1.dataOut\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4476_ clknet_leaf_7_clk _0255_ VGND VGND VPWR VPWR RAM1.mem\[3\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_3358_ RAM1.mem\[22\]\[5\] RAM1.mem\[23\]\[5\] _1137_ VGND VGND VPWR VPWR _1281_
+ sky130_fd_sc_hd__mux2_1
X_3427_ _1116_ _1345_ _1347_ _2069_ VGND VGND VPWR VPWR _1348_ sky130_fd_sc_hd__a211o_1
XTAP_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_308 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3289_ _1116_ _1212_ _1214_ _0456_ VGND VGND VPWR VPWR _1215_ sky130_fd_sc_hd__a211o_1
X_2309_ net17 _2092_ _2093_ VGND VGND VPWR VPWR _2094_ sky130_fd_sc_hd__or3_4
XFILLER_0_90_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2660_ _0579_ _0649_ _0650_ _0654_ _2093_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__a311o_1
XFILLER_0_14_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4330_ clknet_leaf_6_clk _0118_ VGND VGND VPWR VPWR CPU1.RF1.rf\[1\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_2591_ uart_curr_state\[1\] _2091_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__nand2_2
X_4261_ clknet_leaf_25_clk _0014_ VGND VGND VPWR VPWR UART1.UART_RX1.state\[2\] sky130_fd_sc_hd__dfxtp_1
X_3212_ RAM1.mem\[9\]\[0\] _2076_ VGND VGND VPWR VPWR _1140_ sky130_fd_sc_hd__or2_1
X_3143_ _1079_ _1080_ VGND VGND VPWR VPWR _1081_ sky130_fd_sc_hd__xnor2_1
X_3074_ CPU1.PC1.pc_out\[3\] _0941_ _1014_ _1015_ _0879_ VGND VGND VPWR VPWR _0141_
+ sky130_fd_sc_hd__o221a_1
X_4192_ UART1.UART_TX1.clkCount\[7\] VGND VGND VPWR VPWR _1902_ sky130_fd_sc_hd__inv_2
X_2927_ CPU1.RF1.rf\[3\]\[6\] CPU1.RF1.rf\[2\]\[6\] _0848_ VGND VGND VPWR VPWR _0882_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3976_ _2005_ _1735_ _1719_ VGND VGND VPWR VPWR _1736_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_93_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2858_ _0824_ _0825_ _0833_ _0831_ net59 VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__a32o_1
X_2789_ _0591_ _0776_ _0778_ _0600_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__o211a_1
XFILLER_0_32_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4528_ clknet_leaf_23_clk _0305_ VGND VGND VPWR VPWR RAM1.mem\[15\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_4459_ clknet_leaf_10_clk _0238_ VGND VGND VPWR VPWR RAM1.mem\[2\]\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3761_ _0440_ _1581_ _1575_ VGND VGND VPWR VPWR _1582_ sky130_fd_sc_hd__mux2_1
X_3830_ _0489_ _1610_ VGND VGND VPWR VPWR _1630_ sky130_fd_sc_hd__nor2_4
X_3692_ _0437_ _1537_ _1533_ VGND VGND VPWR VPWR _1538_ sky130_fd_sc_hd__mux2_1
X_2712_ RAM1.mem\[4\]\[4\] RAM1.mem\[5\]\[4\] _0495_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__mux2_1
X_2643_ RAM1.mem\[18\]\[1\] RAM1.mem\[19\]\[1\] _0496_ VGND VGND VPWR VPWR _0639_
+ sky130_fd_sc_hd__mux2_1
X_2574_ _1931_ _0386_ _1950_ _0570_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_77_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4175_ UART1.UART_TX1.clkCount\[4\] UART1.UART_TX1.clkCount\[3\] _1881_ VGND VGND
+ VPWR VPWR _1888_ sky130_fd_sc_hd__and3_1
X_4313_ clknet_leaf_24_clk _0101_ VGND VGND VPWR VPWR UART1.UART_RX1.clkCount\[6\]
+ sky130_fd_sc_hd__dfxtp_1
X_4244_ clknet_leaf_21_clk _0039_ VGND VGND VPWR VPWR RAM1.mem\[10\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_22_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3126_ _0972_ _1041_ _1042_ _1019_ _0961_ VGND VGND VPWR VPWR _1065_ sky130_fd_sc_hd__a32o_1
X_3057_ _0980_ _0981_ _0995_ _0906_ _0998_ VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__a221o_1
XFILLER_0_45_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3959_ UART1.UART_RX1.regIn UART1.UART_RX1.dataOut\[0\] _1721_ VGND VGND VPWR VPWR
+ _1722_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2290_ _2074_ VGND VGND VPWR VPWR _2075_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_47_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3813_ _0437_ _1618_ _1614_ VGND VGND VPWR VPWR _1619_ sky130_fd_sc_hd__mux2_1
X_3744_ RAM1.mem\[3\]\[7\] _0413_ _1552_ VGND VGND VPWR VPWR _1569_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_157 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3675_ RAM1.mem\[23\]\[6\] _0482_ _1511_ VGND VGND VPWR VPWR _1525_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2626_ _2063_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__buf_4
X_2557_ net130 _1932_ _0561_ _0557_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__o211a_1
X_2488_ _2071_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__buf_2
X_4227_ clknet_leaf_20_clk _0022_ VGND VGND VPWR VPWR RAM1.mem\[8\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_4158_ _1873_ _1874_ UART1.UART_TX1.clkCount\[0\] VGND VGND VPWR VPWR _1875_ sky130_fd_sc_hd__mux2_1
X_4089_ net86 _0846_ _1819_ _1821_ _1366_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__o221a_1
X_3109_ _0953_ _1048_ VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3460_ _2062_ _1335_ VGND VGND VPWR VPWR _1374_ sky130_fd_sc_hd__nand2_1
X_2411_ _2068_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3391_ RAM1.mem\[16\]\[6\] RAM1.mem\[17\]\[6\] _1119_ VGND VGND VPWR VPWR _1313_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4012_ _0399_ _1762_ _1754_ VGND VGND VPWR VPWR _1763_ sky130_fd_sc_hd__mux2_1
X_2342_ _0398_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__buf_4
X_2273_ net147 _2059_ VGND VGND VPWR VPWR _2060_ sky130_fd_sc_hd__nand2_1
X_3727_ _0434_ _1557_ _1555_ VGND VGND VPWR VPWR _1558_ sky130_fd_sc_hd__mux2_1
XFILLER_0_62_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_168 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2609_ RAM1.mem\[4\]\[0\] RAM1.mem\[5\]\[0\] _0593_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__mux2_1
X_3658_ _1512_ _2087_ _1513_ VGND VGND VPWR VPWR _1514_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_269 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3589_ _1465_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_65_155 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_119 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2960_ _0904_ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__clkbuf_4
X_2891_ CPU1.instr_reg_out\[7\] VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_71_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4561_ clknet_leaf_20_clk _0338_ VGND VGND VPWR VPWR RAM1.mem\[13\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3512_ _0402_ RAM1.mem\[21\]\[5\] _1398_ VGND VGND VPWR VPWR _1411_ sky130_fd_sc_hd__mux2_1
X_3374_ RAM1.mem\[1\]\[5\] _1158_ VGND VGND VPWR VPWR _1297_ sky130_fd_sc_hd__or2_1
XFILLER_0_85_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4492_ clknet_leaf_12_clk _0271_ VGND VGND VPWR VPWR RAM1.mem\[5\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_69_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3443_ _1112_ _1363_ VGND VGND VPWR VPWR _1364_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2325_ _2107_ VGND VGND VPWR VPWR _2108_ sky130_fd_sc_hd__clkbuf_4
X_2256_ run_reg net61 _2047_ _1940_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__o211a_1
X_2187_ UART1.UART_TX1.clkCount\[9\] _1958_ _1984_ _1985_ VGND VGND VPWR VPWR _1986_
+ sky130_fd_sc_hd__o211a_1
XFILLER_0_19_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_294 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_78_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_166 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3090_ _1007_ _1030_ net173 VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold2 UART1.UART_TX1.state\[1\] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__dlygate4sd3_1
X_2943_ _0826_ _0837_ _0888_ _0889_ net96 VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__a32o_1
XFILLER_0_71_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3992_ _2004_ _1701_ UART1.UART_RX1.dataOut\[7\] VGND VGND VPWR VPWR _1748_ sky130_fd_sc_hd__o21a_1
X_2874_ _0830_ _0842_ _0843_ net116 VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__a22o_1
X_4544_ clknet_leaf_26_clk _0321_ VGND VGND VPWR VPWR UART1.UART_RX1.dataOut\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_20_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4475_ clknet_leaf_11_clk _0254_ VGND VGND VPWR VPWR RAM1.mem\[3\]\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3357_ RAM1.mem\[20\]\[5\] RAM1.mem\[21\]\[5\] _1138_ VGND VGND VPWR VPWR _1280_
+ sky130_fd_sc_hd__mux2_1
X_2308_ net16 _1919_ _2090_ VGND VGND VPWR VPWR _2093_ sky130_fd_sc_hd__nand3_4
X_3426_ RAM1.mem\[8\]\[7\] _1144_ _1139_ _1346_ VGND VGND VPWR VPWR _1347_ sky130_fd_sc_hd__o211a_1
X_3288_ RAM1.mem\[0\]\[2\] _1157_ _2078_ _1213_ VGND VGND VPWR VPWR _1214_ sky130_fd_sc_hd__o211a_1
X_2239_ CPU1.instr_reg_out\[3\] VGND VGND VPWR VPWR _2032_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_90_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2590_ _0496_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_1_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3142_ _1040_ _1059_ _1058_ _0945_ VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__o31a_1
X_3211_ _2078_ VGND VGND VPWR VPWR _1139_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_5_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4260_ clknet_leaf_25_clk _0013_ VGND VGND VPWR VPWR UART1.UART_RX1.state\[1\] sky130_fd_sc_hd__dfxtp_2
X_4191_ UART1.UART_TX1.clkCount\[7\] UART1.UART_TX1.clkCount\[6\] _1892_ VGND VGND
+ VPWR VPWR _1901_ sky130_fd_sc_hd__and3_1
X_3073_ net16 _0936_ _0937_ VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__a21o_1
XFILLER_0_49_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2926_ CPU1.RF1.rf\[1\]\[6\] _0849_ _0880_ _0853_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__o211a_1
XFILLER_0_64_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2857_ net76 _0827_ _0829_ CPU1.alu_reg_out\[2\] VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__a22o_2
X_3975_ UART1.UART_RX1.dataOut\[3\] UART1.UART_RX1.regIn _1734_ VGND VGND VPWR VPWR
+ _1735_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4458_ clknet_leaf_7_clk _0237_ VGND VGND VPWR VPWR RAM1.mem\[2\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_86_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2788_ _0595_ _0777_ VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__or2_1
XFILLER_0_40_183 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4527_ clknet_leaf_22_clk _0304_ VGND VGND VPWR VPWR RAM1.mem\[15\]\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4389_ clknet_leaf_4_clk _0168_ VGND VGND VPWR VPWR CPU1.instr_reg_out\[5\] sky130_fd_sc_hd__dfxtp_1
XTAP_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3409_ RAM1.mem\[6\]\[6\] _0459_ _1114_ _1330_ VGND VGND VPWR VPWR _1331_ sky130_fd_sc_hd__o211a_1
XFILLER_0_63_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_59 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3760_ _0390_ RAM1.mem\[4\]\[3\] _1572_ VGND VGND VPWR VPWR _1581_ sky130_fd_sc_hd__mux2_1
X_2711_ RAM1.mem\[6\]\[4\] _0581_ _0587_ RAM1.mem\[7\]\[4\] _0589_ VGND VGND VPWR
+ VPWR _0704_ sky130_fd_sc_hd__a221o_1
XFILLER_0_54_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3691_ RAM1.mem\[2\]\[2\] _0470_ _1530_ VGND VGND VPWR VPWR _1537_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2642_ RAM1.mem\[16\]\[1\] RAM1.mem\[17\]\[1\] _0496_ VGND VGND VPWR VPWR _0638_
+ sky130_fd_sc_hd__mux2_1
X_4312_ clknet_leaf_24_clk _0100_ VGND VGND VPWR VPWR UART1.UART_RX1.clkCount\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2573_ uart_curr_state\[6\] _1942_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__nor2_1
X_3125_ _1062_ _1063_ VGND VGND VPWR VPWR _1064_ sky130_fd_sc_hd__or2b_1
X_4174_ _2058_ _1887_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__nor2_1
X_4243_ clknet_leaf_21_clk _0038_ VGND VGND VPWR VPWR RAM1.mem\[10\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_3056_ _0997_ _0979_ VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__nor2_1
X_2909_ CPU1.RF1.rf\[0\]\[3\] _0850_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__or2_1
XFILLER_0_45_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3889_ _0498_ _1671_ VGND VGND VPWR VPWR _1672_ sky130_fd_sc_hd__nor2_4
X_3958_ _2004_ UART1.UART_RX1.index\[2\] _1695_ VGND VGND VPWR VPWR _1721_ sky130_fd_sc_hd__or3_1
XPHY_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3812_ RAM1.mem\[6\]\[2\] _2107_ _1611_ VGND VGND VPWR VPWR _1618_ sky130_fd_sc_hd__mux2_1
X_3674_ _1524_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__clkbuf_1
X_3743_ _1568_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_27_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_12_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_231 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_100_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2487_ _2070_ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__buf_6
X_2625_ _1923_ _0621_ VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__and2_1
XFILLER_0_10_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2556_ net29 _0560_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__or2_1
X_4088_ _1372_ _2055_ _1820_ _0856_ VGND VGND VPWR VPWR _1821_ sky130_fd_sc_hd__a31o_1
X_3108_ _0910_ _0972_ _0962_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_49_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4157_ _1860_ VGND VGND VPWR VPWR _1874_ sky130_fd_sc_hd__buf_2
X_4226_ clknet_leaf_0_clk _0021_ VGND VGND VPWR VPWR uart_curr_state\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_80_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3039_ _0980_ _0981_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__and2_1
XFILLER_0_80_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_178 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_83_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3390_ _1134_ _1309_ _1311_ _1125_ VGND VGND VPWR VPWR _1312_ sky130_fd_sc_hd__o211a_1
XFILLER_0_58_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2410_ _2066_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__buf_4
X_2341_ net33 _1941_ _2086_ VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__and3_4
XFILLER_0_74_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4011_ RAM1.mem\[14\]\[4\] _0395_ _1751_ VGND VGND VPWR VPWR _1762_ sky130_fd_sc_hd__mux2_1
X_2272_ CPU1.instr_reg_out\[2\] CPU1.instr_reg_out\[1\] CPU1.instr_reg_out\[0\] VGND
+ VGND VPWR VPWR _2059_ sky130_fd_sc_hd__and3_4
XFILLER_0_35_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3726_ RAM1.mem\[3\]\[1\] _2101_ _1552_ VGND VGND VPWR VPWR _1557_ sky130_fd_sc_hd__mux2_1
X_3657_ _0498_ _0522_ VGND VGND VPWR VPWR _1513_ sky130_fd_sc_hd__nor2_4
XFILLER_0_62_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2608_ _0588_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__buf_4
X_2539_ net130 _0550_ _0551_ _0545_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__o211a_1
X_3588_ _1464_ _0393_ _1458_ VGND VGND VPWR VPWR _1465_ sky130_fd_sc_hd__mux2_1
X_4209_ _1913_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2890_ CPU1.RF1.rf\[0\]\[0\] _0850_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__or2_1
XFILLER_0_60_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_156 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_44_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3511_ _1410_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__clkbuf_1
X_4491_ clknet_leaf_12_clk _0270_ VGND VGND VPWR VPWR RAM1.mem\[5\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4560_ clknet_leaf_20_clk _0337_ VGND VGND VPWR VPWR RAM1.mem\[13\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_3373_ RAM1.mem\[2\]\[5\] RAM1.mem\[3\]\[5\] _1155_ VGND VGND VPWR VPWR _1296_ sky130_fd_sc_hd__mux2_1
X_2324_ _2049_ CPU1.reg_a_out\[2\] _2065_ VGND VGND VPWR VPWR _2107_ sky130_fd_sc_hd__and3_2
X_3442_ _0516_ _1340_ _1344_ _1362_ VGND VGND VPWR VPWR _1363_ sky130_fd_sc_hd__o31ai_4
XFILLER_0_20_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2255_ net38 net37 VGND VGND VPWR VPWR _2047_ sky130_fd_sc_hd__or2_1
X_2186_ net10 _1957_ VGND VGND VPWR VPWR _1985_ sky130_fd_sc_hd__or2_1
XFILLER_0_18_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3709_ _0840_ _0825_ _0839_ VGND VGND VPWR VPWR _1549_ sky130_fd_sc_hd__and3_1
XFILLER_0_11_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_178 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_14 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold3 _0016_ VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__dlygate4sd3_1
X_2942_ _0826_ _0836_ _0888_ _0889_ net88 VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__a32o_1
X_2873_ _1951_ _0842_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__nor2_2
XFILLER_0_44_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_156 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3991_ net137 _1720_ _1747_ _1308_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__o211a_1
X_4474_ clknet_leaf_7_clk _0253_ VGND VGND VPWR VPWR RAM1.mem\[3\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_88_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4543_ clknet_leaf_26_clk _0320_ VGND VGND VPWR VPWR UART1.UART_RX1.dataOut\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3287_ RAM1.mem\[1\]\[2\] _1158_ VGND VGND VPWR VPWR _1213_ sky130_fd_sc_hd__or2_1
X_3356_ net92 _1113_ _1279_ _1092_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__o211a_1
X_2238_ CPU1.instr_reg_out\[0\] VGND VGND VPWR VPWR _2031_ sky130_fd_sc_hd__buf_2
X_2307_ _2091_ VGND VGND VPWR VPWR _2092_ sky130_fd_sc_hd__clkbuf_4
X_3425_ RAM1.mem\[9\]\[7\] _2076_ VGND VGND VPWR VPWR _1346_ sky130_fd_sc_hd__or2_1
XFILLER_0_31_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2169_ net1 net2 VGND VGND VPWR VPWR _1968_ sky130_fd_sc_hd__xor2_2
XFILLER_0_50_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3141_ _1029_ _1078_ VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__xnor2_1
X_3210_ _1137_ VGND VGND VPWR VPWR _1138_ sky130_fd_sc_hd__buf_4
X_4190_ UART1.UART_TX1.clkCount\[7\] _1896_ VGND VGND VPWR VPWR _1900_ sky130_fd_sc_hd__nor2_1
X_3072_ _0890_ _1013_ VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__nor2_1
X_2856_ _0824_ _0826_ _0832_ _0831_ net60 VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__a32o_1
X_2925_ CPU1.RF1.rf\[0\]\[6\] _0850_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__or2_1
XFILLER_0_72_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3974_ _1694_ _1688_ _1727_ VGND VGND VPWR VPWR _1734_ sky130_fd_sc_hd__and3_1
X_4457_ clknet_leaf_7_clk _0236_ VGND VGND VPWR VPWR RAM1.mem\[2\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2787_ RAM1.mem\[0\]\[7\] RAM1.mem\[1\]\[7\] _0596_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__mux2_1
X_3408_ RAM1.mem\[7\]\[6\] _2074_ VGND VGND VPWR VPWR _1330_ sky130_fd_sc_hd__or2_1
XFILLER_0_40_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4526_ clknet_leaf_22_clk _0303_ VGND VGND VPWR VPWR RAM1.mem\[15\]\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4388_ clknet_leaf_4_clk _0167_ VGND VGND VPWR VPWR CPU1.instr_reg_out\[4\] sky130_fd_sc_hd__dfxtp_2
XTAP_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3339_ _1116_ _1260_ _1262_ _2069_ VGND VGND VPWR VPWR _1263_ sky130_fd_sc_hd__a211o_1
X_3690_ _1536_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__clkbuf_1
X_2710_ RAM1.mem\[2\]\[4\] _0581_ _0587_ RAM1.mem\[3\]\[4\] _0584_ VGND VGND VPWR
+ VPWR _0703_ sky130_fd_sc_hd__a221o_1
X_2641_ _0580_ _0631_ _0632_ _0636_ _0426_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__a311o_1
X_4242_ clknet_leaf_10_clk _0037_ VGND VGND VPWR VPWR RAM1.mem\[0\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_2572_ net145 _1932_ _0568_ _0569_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__o211a_1
X_4311_ clknet_leaf_24_clk _0099_ VGND VGND VPWR VPWR UART1.UART_RX1.clkCount\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_22_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3124_ _1057_ _1061_ VGND VGND VPWR VPWR _1063_ sky130_fd_sc_hd__nand2_1
X_3055_ _0907_ VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__inv_2
X_4173_ _1873_ _1884_ _1885_ _1874_ _1886_ VGND VGND VPWR VPWR _1887_ sky130_fd_sc_hd__o32a_1
XFILLER_0_42_70 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3957_ _1719_ VGND VGND VPWR VPWR _1720_ sky130_fd_sc_hd__buf_2
X_2908_ net165 _0847_ _0864_ _0866_ _0623_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__o221a_1
X_3888_ _2093_ net17 _2092_ VGND VGND VPWR VPWR _1671_ sky130_fd_sc_hd__or3b_4
X_2839_ UART1.UART_RX1.clkCount\[8\] _0816_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__or2_1
X_4509_ clknet_leaf_6_clk _0288_ VGND VGND VPWR VPWR RAM1.mem\[7\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_143 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3811_ _1617_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__clkbuf_1
X_3673_ _1523_ _0404_ _1513_ VGND VGND VPWR VPWR _1524_ sky130_fd_sc_hd__mux2_1
X_3742_ _0449_ _1567_ _1555_ VGND VGND VPWR VPWR _1568_ sky130_fd_sc_hd__mux2_1
X_2624_ _0521_ _0602_ _0610_ _0620_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__a31o_1
XFILLER_0_27_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2486_ _2061_ CPU1.PC1.pc_out\[2\] net172 CPU1.reg_b_out\[2\] VGND VGND VPWR VPWR
+ _0515_ sky130_fd_sc_hd__a22oi_4
X_4225_ clknet_leaf_2_clk _0008_ VGND VGND VPWR VPWR UART1.TX_en sky130_fd_sc_hd__dfxtp_1
X_2555_ _1931_ uart_curr_state\[6\] VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__and2_2
X_4087_ CPU1.RF1.rf\[3\]\[6\] CPU1.RF1.rf\[2\]\[6\] _1790_ VGND VGND VPWR VPWR _1820_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3107_ _1044_ _1045_ _0924_ VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__o21a_1
X_3038_ _0942_ _0949_ _0948_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__a21bo_1
X_4156_ _1872_ VGND VGND VPWR VPWR _1873_ sky130_fd_sc_hd__buf_2
XFILLER_0_3_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2340_ _0396_ RAM1.mem\[8\]\[4\] _2081_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__mux2_1
X_2271_ _1951_ VGND VGND VPWR VPWR _2058_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_74_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4010_ _1761_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_202 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2607_ RAM1.mem\[6\]\[0\] _0586_ _0587_ RAM1.mem\[7\]\[0\] _0589_ VGND VGND VPWR
+ VPWR _0604_ sky130_fd_sc_hd__a221o_1
X_3725_ _1556_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__clkbuf_1
X_3656_ RAM1.mem\[23\]\[0\] _0455_ _1511_ VGND VGND VPWR VPWR _1512_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_9_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_9_clk sky130_fd_sc_hd__clkbuf_16
X_3587_ RAM1.mem\[18\]\[3\] _0473_ _1455_ VGND VGND VPWR VPWR _1464_ sky130_fd_sc_hd__mux2_1
XFILLER_0_100_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2538_ net13 _1944_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__or2_1
X_4208_ net148 net41 _1989_ VGND VGND VPWR VPWR _1913_ sky130_fd_sc_hd__mux2_1
X_2469_ _0503_ _0387_ _0499_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__mux2_1
XFILLER_0_65_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4139_ _1852_ _1859_ VGND VGND VPWR VPWR _1860_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_88_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3510_ _0443_ _1409_ _1401_ VGND VGND VPWR VPWR _1410_ sky130_fd_sc_hd__mux2_1
X_4490_ clknet_leaf_13_clk _0269_ VGND VGND VPWR VPWR RAM1.mem\[5\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_69_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3441_ _0517_ _1348_ _1352_ _1361_ VGND VGND VPWR VPWR _1362_ sky130_fd_sc_hd__a31o_1
X_2254_ _2029_ _2036_ _2039_ _2046_ CPU1.curr_state\[4\] VGND VGND VPWR VPWR net37
+ sky130_fd_sc_hd__a2111o_2
X_3372_ _1128_ _1292_ _1294_ _1131_ VGND VGND VPWR VPWR _1295_ sky130_fd_sc_hd__a211o_1
X_2323_ _2106_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2185_ UART1.UART_TX1.clkCount\[8\] _1960_ _1958_ UART1.UART_TX1.clkCount\[9\] _1983_
+ VGND VGND VPWR VPWR _1984_ sky130_fd_sc_hd__a221o_1
XFILLER_0_62_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3708_ _1548_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__clkbuf_1
X_3639_ _1500_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__clkbuf_1
XPHY_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold4 UART1.UART_TX1.state\[0\] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__dlygate4sd3_1
X_3990_ _2005_ _1746_ _1719_ VGND VGND VPWR VPWR _1747_ sky130_fd_sc_hd__a21bo_1
X_2941_ _0826_ _0835_ _0888_ _0889_ net81 VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__a32o_1
X_2872_ _0841_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_84_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4473_ clknet_leaf_7_clk _0252_ VGND VGND VPWR VPWR RAM1.mem\[3\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_4542_ clknet_leaf_0_clk _0319_ VGND VGND VPWR VPWR UART1.RX_dataOut\[7\] sky130_fd_sc_hd__dfxtp_1
X_3424_ RAM1.mem\[10\]\[7\] RAM1.mem\[11\]\[7\] _1135_ VGND VGND VPWR VPWR _1345_
+ sky130_fd_sc_hd__mux2_1
XTAP_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3286_ RAM1.mem\[2\]\[2\] RAM1.mem\[3\]\[2\] _0459_ VGND VGND VPWR VPWR _1212_ sky130_fd_sc_hd__mux2_1
X_3355_ _1112_ _1278_ VGND VGND VPWR VPWR _1279_ sky130_fd_sc_hd__nand2_1
X_2306_ net15 _2090_ VGND VGND VPWR VPWR _2091_ sky130_fd_sc_hd__and2_1
X_2237_ CPU1.instr_reg_out\[1\] VGND VGND VPWR VPWR _2030_ sky130_fd_sc_hd__inv_2
XFILLER_0_0_72 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2168_ _1962_ _1966_ VGND VGND VPWR VPWR _1967_ sky130_fd_sc_hd__and2_1
XFILLER_0_61_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_238 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3140_ CPU1.reg_b_out\[7\] _2051_ _1039_ VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__o21ai_2
X_3071_ _0943_ _1003_ _1006_ _1012_ VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__o211a_1
X_3973_ net131 _1720_ _1733_ _1308_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__o211a_1
X_2924_ net152 _0847_ _0876_ _0878_ _0879_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__o221a_1
X_2855_ net70 _0827_ _0829_ CPU1.alu_reg_out\[1\] VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__a22o_2
X_2786_ RAM1.mem\[4\]\[7\] RAM1.mem\[5\]\[7\] _0593_ VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__mux2_1
X_4525_ clknet_leaf_22_clk _0302_ VGND VGND VPWR VPWR RAM1.mem\[15\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4456_ clknet_leaf_10_clk _0235_ VGND VGND VPWR VPWR RAM1.mem\[2\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_3407_ RAM1.mem\[4\]\[6\] RAM1.mem\[5\]\[6\] _0458_ VGND VGND VPWR VPWR _1329_ sky130_fd_sc_hd__mux2_1
XTAP_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4387_ clknet_leaf_2_clk _0166_ VGND VGND VPWR VPWR CPU1.instr_reg_out\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3338_ RAM1.mem\[8\]\[4\] _1144_ _1139_ _1261_ VGND VGND VPWR VPWR _1262_ sky130_fd_sc_hd__o211a_1
XFILLER_0_0_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3269_ net70 _1113_ _1195_ _1092_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__o211a_1
XTAP_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_98_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2640_ _0591_ _0633_ _0635_ _0600_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__o211a_1
XFILLER_0_54_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4241_ clknet_leaf_11_clk _0036_ VGND VGND VPWR VPWR RAM1.mem\[0\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2571_ _2063_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__clkbuf_4
X_4310_ clknet_leaf_24_clk _0098_ VGND VGND VPWR VPWR UART1.UART_RX1.clkCount\[3\]
+ sky130_fd_sc_hd__dfxtp_2
XFILLER_0_22_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_93_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3123_ _1057_ _1061_ VGND VGND VPWR VPWR _1062_ sky130_fd_sc_hd__nor2_1
XFILLER_0_89_174 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3054_ _0906_ _0995_ VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__nor2_1
X_4172_ UART1.UART_TX1.clkCount\[3\] VGND VGND VPWR VPWR _1886_ sky130_fd_sc_hd__inv_2
X_2907_ _0852_ _2056_ _0865_ _0857_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__a31o_1
XFILLER_0_42_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3956_ UART1.UART_RX1.state\[3\] _2025_ _0798_ VGND VGND VPWR VPWR _1719_ sky130_fd_sc_hd__and3b_2
XFILLER_0_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4508_ clknet_leaf_7_clk _0287_ VGND VGND VPWR VPWR RAM1.mem\[7\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_2769_ RAM1.mem\[22\]\[6\] RAM1.mem\[23\]\[6\] _0494_ VGND VGND VPWR VPWR _0760_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3887_ RAM1.mem\[15\]\[0\] _0455_ _1669_ VGND VGND VPWR VPWR _1670_ sky130_fd_sc_hd__mux2_1
X_2838_ UART1.UART_RX1.clkCount\[8\] _0816_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__nand2_1
X_4439_ clknet_leaf_16_clk _0218_ VGND VGND VPWR VPWR RAM1.mem\[17\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_155 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3810_ _0434_ _1616_ _1614_ VGND VGND VPWR VPWR _1617_ sky130_fd_sc_hd__mux2_1
X_3741_ RAM1.mem\[3\]\[6\] _0407_ _1552_ VGND VGND VPWR VPWR _1567_ sky130_fd_sc_hd__mux2_1
X_3672_ RAM1.mem\[23\]\[5\] _0479_ _1511_ VGND VGND VPWR VPWR _1523_ sky130_fd_sc_hd__mux2_1
X_2623_ _2092_ _0614_ _0619_ _0430_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__o211a_1
X_2554_ net145 _0550_ _0559_ _0557_ VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__o211a_1
XFILLER_0_27_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2485_ _0514_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__clkbuf_1
X_4155_ _1852_ _1986_ _1859_ VGND VGND VPWR VPWR _1872_ sky130_fd_sc_hd__or3b_1
X_4224_ clknet_leaf_0_clk _0020_ VGND VGND VPWR VPWR uart_curr_state\[4\] sky130_fd_sc_hd__dfxtp_1
X_4086_ CPU1.RF1.rf\[1\]\[6\] _1791_ _1818_ _1794_ VGND VGND VPWR VPWR _1819_ sky130_fd_sc_hd__o211a_1
XFILLER_0_77_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3106_ _1044_ _1045_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__nand2_1
X_3037_ _0907_ _0979_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3939_ _1709_ VGND VGND VPWR VPWR _1710_ sky130_fd_sc_hd__buf_2
XFILLER_0_24_203 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2270_ _2057_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_59_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3724_ _0419_ _1553_ _1555_ VGND VGND VPWR VPWR _1556_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2606_ RAM1.mem\[2\]\[0\] _0586_ _0583_ RAM1.mem\[3\]\[0\] _0584_ VGND VGND VPWR
+ VPWR _0603_ sky130_fd_sc_hd__a221o_1
X_3655_ _0489_ _0518_ VGND VGND VPWR VPWR _1511_ sky130_fd_sc_hd__nor2_4
X_2537_ _1931_ uart_curr_state\[2\] VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__nand2_4
X_3586_ _1463_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__clkbuf_1
X_2399_ _0402_ RAM1.mem\[0\]\[5\] _0423_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__mux2_1
X_4207_ _1912_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__clkbuf_1
X_2468_ RAM1.mem\[11\]\[2\] _0470_ _0490_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__mux2_1
X_4138_ UART1.UART_TX1.state\[1\] UART1.UART_TX1.state\[0\] VGND VGND VPWR VPWR _1859_
+ sky130_fd_sc_hd__nor2_1
X_4069_ net160 _0846_ _1803_ _1805_ _0879_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__o221a_1
XFILLER_0_65_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3440_ _1149_ _1356_ _1360_ _1162_ VGND VGND VPWR VPWR _1361_ sky130_fd_sc_hd__a31o_1
X_3371_ RAM1.mem\[14\]\[5\] _1144_ _1145_ _1293_ VGND VGND VPWR VPWR _1294_ sky130_fd_sc_hd__o211a_1
XFILLER_0_20_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2253_ _2041_ _2044_ net50 CPU1.curr_state\[1\] VGND VGND VPWR VPWR _2046_ sky130_fd_sc_hd__o31a_4
X_2322_ _2103_ _2105_ _2099_ VGND VGND VPWR VPWR _2106_ sky130_fd_sc_hd__mux2_1
X_2184_ _1981_ _1982_ _1960_ UART1.UART_TX1.clkCount\[8\] VGND VGND VPWR VPWR _1983_
+ sky130_fd_sc_hd__o22a_1
XFILLER_0_87_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_79_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3707_ _0452_ _1547_ _1533_ VGND VGND VPWR VPWR _1548_ sky130_fd_sc_hd__mux2_1
X_3569_ _0449_ _1450_ _1438_ VGND VGND VPWR VPWR _1451_ sky130_fd_sc_hd__mux2_1
X_3638_ _1499_ _0387_ _1495_ VGND VGND VPWR VPWR _1500_ sky130_fd_sc_hd__mux2_1
XPHY_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold5 CPU1.RF1.rf\[3\]\[7\] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2940_ _0826_ _0834_ _0888_ _0889_ net71 VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__a32o_1
X_2871_ _0839_ _0840_ _0825_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__and3b_1
XFILLER_0_84_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4541_ clknet_leaf_0_clk _0318_ VGND VGND VPWR VPWR UART1.RX_dataOut\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4472_ clknet_leaf_8_clk _0251_ VGND VGND VPWR VPWR RAM1.mem\[3\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_3354_ _0516_ _1255_ _1259_ _1277_ VGND VGND VPWR VPWR _1278_ sky130_fd_sc_hd__o31ai_2
XFILLER_0_52_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3423_ _1117_ _1341_ _1343_ _1132_ VGND VGND VPWR VPWR _1344_ sky130_fd_sc_hd__o211a_1
XFILLER_0_20_63 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2236_ _2028_ VGND VGND VPWR VPWR _2029_ sky130_fd_sc_hd__clkbuf_4
X_2305_ _2089_ VGND VGND VPWR VPWR _2090_ sky130_fd_sc_hd__clkbuf_4
X_3285_ _1128_ _1208_ _1210_ _1131_ VGND VGND VPWR VPWR _1211_ sky130_fd_sc_hd__a211o_1
XFILLER_0_17_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2167_ net1 net2 net3 VGND VGND VPWR VPWR _1966_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_28_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3070_ _0894_ _1009_ _1010_ _1011_ VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__a211oi_1
X_2923_ _2063_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_57_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3972_ _2005_ _1732_ _1719_ VGND VGND VPWR VPWR _1733_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_9_306 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2854_ _0824_ _0826_ _0830_ _0831_ net68 VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__a32o_1
X_2785_ RAM1.mem\[6\]\[7\] _0586_ _0583_ RAM1.mem\[7\]\[7\] _0589_ VGND VGND VPWR
+ VPWR _0775_ sky130_fd_sc_hd__a221o_1
XFILLER_0_40_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4524_ clknet_leaf_23_clk _0301_ VGND VGND VPWR VPWR RAM1.mem\[15\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_4455_ clknet_leaf_13_clk _0234_ VGND VGND VPWR VPWR RAM1.mem\[23\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3406_ _1145_ _1325_ _1327_ _0456_ VGND VGND VPWR VPWR _1328_ sky130_fd_sc_hd__a211o_1
XTAP_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4386_ clknet_leaf_2_clk _0165_ VGND VGND VPWR VPWR CPU1.instr_reg_out\[2\] sky130_fd_sc_hd__dfxtp_1
X_3337_ RAM1.mem\[9\]\[4\] _2076_ VGND VGND VPWR VPWR _1261_ sky130_fd_sc_hd__or2_1
X_3268_ _1113_ _1194_ VGND VGND VPWR VPWR _1195_ sky130_fd_sc_hd__nand2_1
XTAP_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3199_ RAM1.mem\[16\]\[0\] RAM1.mem\[17\]\[0\] _1119_ VGND VGND VPWR VPWR _1127_
+ sky130_fd_sc_hd__mux2_1
X_2219_ _2012_ _2013_ _2014_ _1985_ VGND VGND VPWR VPWR _2015_ sky130_fd_sc_hd__or4b_1
XFILLER_0_48_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2570_ net36 _0560_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__or2_1
XFILLER_0_6_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4240_ clknet_leaf_11_clk _0035_ VGND VGND VPWR VPWR RAM1.mem\[0\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_3122_ _1058_ _1060_ VGND VGND VPWR VPWR _1061_ sky130_fd_sc_hd__xnor2_1
X_4171_ UART1.UART_TX1.clkCount\[3\] _1881_ VGND VGND VPWR VPWR _1885_ sky130_fd_sc_hd__and2_1
XFILLER_0_89_186 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_89_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3053_ _0993_ _0994_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__xnor2_2
X_2906_ CPU1.RF1.rf\[3\]\[2\] CPU1.RF1.rf\[2\]\[2\] _0848_ VGND VGND VPWR VPWR _0865_
+ sky130_fd_sc_hd__mux2_1
X_3886_ _0489_ _1668_ VGND VGND VPWR VPWR _1669_ sky130_fd_sc_hd__nor2_4
XFILLER_0_45_234 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3955_ _1718_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__clkbuf_1
X_4507_ clknet_leaf_7_clk _0286_ VGND VGND VPWR VPWR RAM1.mem\[7\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_84_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2768_ RAM1.mem\[20\]\[6\] RAM1.mem\[21\]\[6\] _0494_ VGND VGND VPWR VPWR _0759_
+ sky130_fd_sc_hd__mux2_1
X_2699_ _2092_ _0690_ _0692_ _0430_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__o211a_1
X_4438_ clknet_leaf_16_clk _0217_ VGND VGND VPWR VPWR RAM1.mem\[17\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_2837_ _0816_ _0817_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__nor2_1
XFILLER_0_67_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4369_ clknet_leaf_3_clk _0148_ VGND VGND VPWR VPWR CPU1.alu_reg_out\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3740_ _1566_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3671_ _1522_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__clkbuf_1
X_2622_ _0615_ _0618_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__or2_1
X_2553_ net20 _1944_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__or2_1
XFILLER_0_10_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4085_ CPU1.RF1.rf\[0\]\[6\] _1792_ VGND VGND VPWR VPWR _1818_ sky130_fd_sc_hd__or2_1
X_3105_ _0961_ _1019_ _1021_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__a21o_1
X_2484_ _0513_ _0417_ _0499_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__mux2_1
X_4223_ clknet_leaf_0_clk _0019_ VGND VGND VPWR VPWR uart_curr_state\[3\] sky130_fd_sc_hd__dfxtp_1
X_4154_ _1871_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3036_ _0969_ _0978_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__xnor2_1
X_3869_ _1657_ _0392_ _1651_ VGND VGND VPWR VPWR _1658_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3938_ UART1.UART_RX1.state\[3\] _1939_ _2002_ VGND VGND VPWR VPWR _1709_ sky130_fd_sc_hd__and3_1
XFILLER_0_68_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_90_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3723_ _1554_ VGND VGND VPWR VPWR _1555_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_15_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3654_ _1510_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__clkbuf_1
X_2536_ net145 _1937_ _0549_ _0545_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__o211a_1
X_2605_ _0580_ _0585_ _0590_ _0601_ _2093_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__a311o_1
XFILLER_0_2_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2467_ _0502_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__clkbuf_1
X_3585_ _1462_ _0387_ _1458_ VGND VGND VPWR VPWR _1463_ sky130_fd_sc_hd__mux2_1
XFILLER_0_23_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4068_ _1372_ _2055_ _1804_ _0856_ VGND VGND VPWR VPWR _1805_ sky130_fd_sc_hd__a31o_1
X_2398_ _0404_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__buf_2
XFILLER_0_64_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4206_ net122 net40 _1989_ VGND VGND VPWR VPWR _1912_ sky130_fd_sc_hd__mux2_1
X_4137_ _1857_ _1986_ _1852_ VGND VGND VPWR VPWR _1858_ sky130_fd_sc_hd__a21oi_2
X_3019_ _0910_ _0906_ _0962_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_38_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_96_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_37 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3370_ RAM1.mem\[15\]\[5\] _2075_ VGND VGND VPWR VPWR _1293_ sky130_fd_sc_hd__or2_1
X_2321_ _2104_ VGND VGND VPWR VPWR _2105_ sky130_fd_sc_hd__buf_4
XFILLER_0_20_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2252_ _2032_ _2033_ CPU1.instr_reg_out\[1\] _2031_ VGND VGND VPWR VPWR _2045_ sky130_fd_sc_hd__nor4_1
X_2183_ UART1.UART_TX1.clkCount\[7\] _1979_ VGND VGND VPWR VPWR _1982_ sky130_fd_sc_hd__and2_1
XFILLER_0_18_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3706_ RAM1.mem\[2\]\[7\] _0485_ _1530_ VGND VGND VPWR VPWR _1547_ sky130_fd_sc_hd__mux2_1
XFILLER_0_50_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3637_ RAM1.mem\[19\]\[2\] _0470_ _1493_ VGND VGND VPWR VPWR _1499_ sky130_fd_sc_hd__mux2_1
X_3568_ _0408_ RAM1.mem\[1\]\[6\] _1435_ VGND VGND VPWR VPWR _1450_ sky130_fd_sc_hd__mux2_1
X_3499_ _1402_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__clkbuf_1
X_2519_ _1931_ uart_curr_state\[4\] VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__and2_2
XPHY_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_254 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold6 CPU1.RF1.rf\[3\]\[2\] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__dlygate4sd3_1
X_2870_ CPU1.instr_reg_out\[7\] _2046_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__nand2_2
X_4471_ clknet_leaf_5_clk _0250_ VGND VGND VPWR VPWR CPU1.RF1.rf\[0\]\[7\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_10_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_10_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_37_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4540_ clknet_leaf_0_clk _0317_ VGND VGND VPWR VPWR UART1.RX_dataOut\[5\] sky130_fd_sc_hd__dfxtp_1
XTAP_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3353_ _0517_ _1263_ _1267_ _1276_ VGND VGND VPWR VPWR _1277_ sky130_fd_sc_hd__a31o_1
X_2304_ _1923_ _2085_ VGND VGND VPWR VPWR _2089_ sky130_fd_sc_hd__or2_1
X_3284_ RAM1.mem\[14\]\[2\] _1144_ _1145_ _1209_ VGND VGND VPWR VPWR _1210_ sky130_fd_sc_hd__o211a_1
X_3422_ _1121_ _1342_ VGND VGND VPWR VPWR _1343_ sky130_fd_sc_hd__or2_1
X_2235_ CPU1.curr_state\[5\] VGND VGND VPWR VPWR _2028_ sky130_fd_sc_hd__buf_2
X_2166_ UART1.UART_TX1.clkCount\[3\] _1964_ _1961_ UART1.UART_TX1.clkCount\[4\] VGND
+ VGND VPWR VPWR _1965_ sky130_fd_sc_hd__a22o_1
XFILLER_0_75_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2999_ CPU1.curr_state\[5\] _2041_ _0898_ _0921_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__a211o_4
XFILLER_0_0_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_101_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_1_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_66_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_276 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_66_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2853_ _1951_ _0824_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__nor2_2
X_2922_ _0852_ _2056_ _0877_ _0857_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__a31o_1
XFILLER_0_57_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3971_ UART1.UART_RX1.dataOut\[2\] _1730_ _1731_ _1727_ VGND VGND VPWR VPWR _1732_
+ sky130_fd_sc_hd__a22o_1
XFILLER_0_9_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2784_ RAM1.mem\[2\]\[7\] _0582_ _0497_ RAM1.mem\[3\]\[7\] _0584_ VGND VGND VPWR
+ VPWR _0774_ sky130_fd_sc_hd__a221o_1
X_4454_ clknet_leaf_14_clk _0233_ VGND VGND VPWR VPWR RAM1.mem\[23\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_4523_ clknet_leaf_22_clk _0300_ VGND VGND VPWR VPWR RAM1.mem\[15\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3405_ RAM1.mem\[0\]\[6\] _1157_ _2077_ _1326_ VGND VGND VPWR VPWR _1327_ sky130_fd_sc_hd__o211a_1
XTAP_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4385_ clknet_leaf_4_clk _0164_ VGND VGND VPWR VPWR CPU1.instr_reg_out\[1\] sky130_fd_sc_hd__dfxtp_2
XTAP_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3267_ _0516_ _1170_ _1174_ _1193_ VGND VGND VPWR VPWR _1194_ sky130_fd_sc_hd__o31ai_4
XFILLER_0_0_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3336_ RAM1.mem\[10\]\[4\] RAM1.mem\[11\]\[4\] _1135_ VGND VGND VPWR VPWR _1260_
+ sky130_fd_sc_hd__mux2_1
X_3198_ _1117_ _1120_ _1124_ _1125_ VGND VGND VPWR VPWR _1126_ sky130_fd_sc_hd__o211a_1
XFILLER_0_48_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2218_ UART1.UART_RX1.clkCount\[4\] _1973_ VGND VGND VPWR VPWR _2014_ sky130_fd_sc_hd__xnor2_1
X_2149_ _1949_ _1942_ _1943_ _1940_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__o31a_1
XFILLER_0_63_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3121_ _0945_ _1040_ _1059_ VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_77_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4170_ UART1.UART_TX1.clkCount\[3\] _1881_ VGND VGND VPWR VPWR _1884_ sky130_fd_sc_hd__nor2_1
XFILLER_0_89_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3052_ _0912_ _0900_ _0969_ _0945_ VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__o31a_1
XFILLER_0_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2905_ CPU1.RF1.rf\[1\]\[2\] _0849_ _0863_ _0853_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__o211a_1
XFILLER_0_60_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3885_ _1190_ _2072_ VGND VGND VPWR VPWR _1668_ sky130_fd_sc_hd__or2_2
XFILLER_0_45_246 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2836_ net169 _0814_ _0799_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__o21ai_1
X_3954_ net146 net124 _1710_ VGND VGND VPWR VPWR _1718_ sky130_fd_sc_hd__mux2_1
X_4506_ clknet_leaf_7_clk _0285_ VGND VGND VPWR VPWR RAM1.mem\[7\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_2698_ _0615_ _0691_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__or2_1
X_2767_ _0756_ _0757_ _0577_ VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__mux2_1
X_4437_ clknet_leaf_17_clk _0216_ VGND VGND VPWR VPWR RAM1.mem\[17\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_3319_ RAM1.mem\[4\]\[3\] RAM1.mem\[5\]\[3\] _1155_ VGND VGND VPWR VPWR _1244_ sky130_fd_sc_hd__mux2_1
X_4299_ clknet_leaf_3_clk _0090_ VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__dfxtp_2
X_4368_ clknet_leaf_2_clk _0147_ VGND VGND VPWR VPWR CPU1.alu_reg_out\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3670_ _1521_ _0398_ _1513_ VGND VGND VPWR VPWR _1522_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2621_ _0616_ _0617_ _0578_ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__mux2_1
X_2552_ net139 _0550_ _0558_ _0557_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__o211a_1
X_4222_ clknet_leaf_0_clk _0018_ VGND VGND VPWR VPWR uart_curr_state\[2\] sky130_fd_sc_hd__dfxtp_1
X_2483_ RAM1.mem\[11\]\[7\] _0485_ _0490_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__mux2_1
X_3104_ _0972_ _1043_ VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__xor2_1
X_4084_ net109 _0846_ _1815_ _1817_ _0879_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__o221a_1
X_3035_ _0912_ _0900_ _0945_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_37_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4153_ _1862_ _1869_ _1870_ VGND VGND VPWR VPWR _1871_ sky130_fd_sc_hd__and3_1
X_3937_ _1706_ _1708_ _1952_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_18_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3799_ _0485_ RAM1.mem\[5\]\[7\] _1591_ VGND VGND VPWR VPWR _1608_ sky130_fd_sc_hd__mux2_1
X_3868_ _0390_ RAM1.mem\[16\]\[3\] _1649_ VGND VGND VPWR VPWR _1657_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2819_ UART1.UART_RX1.clkCount\[1\] UART1.UART_RX1.clkCount\[0\] UART1.UART_RX1.clkCount\[2\]
+ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__a21o_1
XFILLER_0_83_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3722_ _0425_ _0428_ _0429_ _0498_ VGND VGND VPWR VPWR _1554_ sky130_fd_sc_hd__or4_1
XFILLER_0_15_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3653_ _1509_ _0417_ _1495_ VGND VGND VPWR VPWR _1510_ sky130_fd_sc_hd__mux2_1
X_2604_ _0591_ _0594_ _0598_ _0600_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__o211a_1
XFILLER_0_48_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2535_ net28 _0540_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__or2_1
X_4205_ _1911_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__clkbuf_1
X_2466_ _0501_ _2105_ _0499_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3584_ RAM1.mem\[18\]\[2\] _0470_ _1455_ VGND VGND VPWR VPWR _1462_ sky130_fd_sc_hd__mux2_1
X_2397_ _0445_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__clkbuf_1
X_4067_ CPU1.RF1.rf\[3\]\[2\] CPU1.RF1.rf\[2\]\[2\] _1790_ VGND VGND VPWR VPWR _1804_
+ sky130_fd_sc_hd__mux2_1
X_3018_ net173 _0961_ VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__nand2_1
X_4136_ _1953_ VGND VGND VPWR VPWR _1857_ sky130_fd_sc_hd__inv_2
XFILLER_0_73_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_88_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2251_ _2042_ _2043_ VGND VGND VPWR VPWR _2044_ sky130_fd_sc_hd__nand2_2
X_2320_ net30 _1941_ _2086_ VGND VGND VPWR VPWR _2104_ sky130_fd_sc_hd__and3_4
XFILLER_0_20_230 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2182_ _1975_ _1978_ _1979_ UART1.UART_TX1.clkCount\[7\] _1980_ VGND VGND VPWR VPWR
+ _1981_ sky130_fd_sc_hd__o221a_1
X_3567_ _1449_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__clkbuf_1
X_3705_ _1546_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__clkbuf_1
X_3636_ _1498_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__clkbuf_1
X_3498_ _0419_ _1399_ _1401_ VGND VGND VPWR VPWR _1402_ sky130_fd_sc_hd__mux2_1
X_2518_ _0539_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__clkbuf_1
X_2449_ _0486_ _0417_ _0465_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__mux2_1
XPHY_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4119_ _1842_ _0416_ _1828_ VGND VGND VPWR VPWR _1843_ sky130_fd_sc_hd__mux2_1
XFILLER_0_93_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold7 CPU1.RF1.rf\[3\]\[1\] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_84_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_69_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4470_ clknet_leaf_6_clk _0249_ VGND VGND VPWR VPWR CPU1.RF1.rf\[0\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_52_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3421_ RAM1.mem\[18\]\[7\] RAM1.mem\[19\]\[7\] _1122_ VGND VGND VPWR VPWR _1342_
+ sky130_fd_sc_hd__mux2_1
XTAP_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3352_ _1149_ _1271_ _1275_ _1162_ VGND VGND VPWR VPWR _1276_ sky130_fd_sc_hd__a31o_1
X_3283_ RAM1.mem\[15\]\[2\] _2075_ VGND VGND VPWR VPWR _1209_ sky130_fd_sc_hd__or2_1
XFILLER_0_29_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2234_ net110 UART1.UART_RX1.regIn _2027_ _1952_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__a211o_1
X_2303_ _2087_ VGND VGND VPWR VPWR _2088_ sky130_fd_sc_hd__buf_4
XFILLER_0_45_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2165_ _1954_ _1963_ VGND VGND VPWR VPWR _1964_ sky130_fd_sc_hd__and2_2
XFILLER_0_75_299 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2998_ net49 _0914_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__or2_1
XFILLER_0_0_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4599_ clknet_leaf_22_clk _0376_ VGND VGND VPWR VPWR UART1.UART_TX1.packet\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3619_ _1486_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_66_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3970_ _1688_ UART1.UART_RX1.regIn _1694_ VGND VGND VPWR VPWR _1731_ sky130_fd_sc_hd__and3b_1
XFILLER_0_15_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2921_ CPU1.RF1.rf\[3\]\[5\] CPU1.RF1.rf\[2\]\[5\] _0848_ VGND VGND VPWR VPWR _0877_
+ sky130_fd_sc_hd__mux2_1
X_2852_ net74 _0827_ _0829_ CPU1.alu_reg_out\[0\] VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__a22o_2
X_2783_ _0580_ _0767_ _0768_ _0772_ _2093_ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__a311o_1
X_3404_ RAM1.mem\[1\]\[6\] _1158_ VGND VGND VPWR VPWR _1326_ sky130_fd_sc_hd__or2_1
X_4453_ clknet_leaf_14_clk _0232_ VGND VGND VPWR VPWR RAM1.mem\[23\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_4384_ clknet_leaf_4_clk _0163_ VGND VGND VPWR VPWR CPU1.instr_reg_out\[0\] sky130_fd_sc_hd__dfxtp_1
X_4522_ clknet_leaf_0_clk _0299_ VGND VGND VPWR VPWR UART1.RX_done sky130_fd_sc_hd__dfxtp_1
XTAP_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3197_ _2069_ VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__clkbuf_4
XTAP_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3266_ _0517_ _1178_ _1182_ _1192_ VGND VGND VPWR VPWR _1193_ sky130_fd_sc_hd__a31o_1
X_3335_ _1117_ _1256_ _1258_ _1132_ VGND VGND VPWR VPWR _1259_ sky130_fd_sc_hd__o211a_2
X_2217_ UART1.UART_RX1.clkCount\[3\] _1961_ VGND VGND VPWR VPWR _2013_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_22_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2148_ _1948_ _1929_ VGND VGND VPWR VPWR _1949_ sky130_fd_sc_hd__nor2_1
XFILLER_0_63_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3120_ net48 _1038_ VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__nand2_1
X_3051_ _2028_ _0991_ _0992_ _0898_ CPU1.instr_reg_out\[6\] VGND VGND VPWR VPWR _0993_
+ sky130_fd_sc_hd__a32o_2
XFILLER_0_92_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_138 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3953_ _1717_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_26_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2904_ CPU1.RF1.rf\[0\]\[2\] _0850_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__or2_1
XFILLER_0_45_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2766_ RAM1.mem\[18\]\[6\] RAM1.mem\[19\]\[6\] _0494_ VGND VGND VPWR VPWR _0757_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2835_ UART1.UART_RX1.clkCount\[7\] UART1.UART_RX1.clkCount\[6\] _0811_ VGND VGND
+ VPWR VPWR _0816_ sky130_fd_sc_hd__and3_1
X_3884_ _2027_ _1667_ _1940_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__o21a_1
X_4505_ clknet_leaf_7_clk _0284_ VGND VGND VPWR VPWR RAM1.mem\[7\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_3318_ _1116_ _1240_ _1242_ _0456_ VGND VGND VPWR VPWR _1243_ sky130_fd_sc_hd__a211o_1
X_2697_ RAM1.mem\[20\]\[3\] RAM1.mem\[21\]\[3\] RAM1.mem\[22\]\[3\] RAM1.mem\[23\]\[3\]
+ _0495_ _0578_ VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__mux4_1
X_4367_ clknet_leaf_2_clk _0146_ VGND VGND VPWR VPWR CPU1.z_flag_out sky130_fd_sc_hd__dfxtp_1
X_4436_ clknet_leaf_18_clk _0215_ VGND VGND VPWR VPWR RAM1.mem\[17\]\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4298_ clknet_leaf_2_clk _0089_ VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__dfxtp_2
XTAP_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3249_ RAM1.mem\[9\]\[1\] _2076_ VGND VGND VPWR VPWR _1176_ sky130_fd_sc_hd__or2_1
XTAP_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2620_ RAM1.mem\[22\]\[0\] RAM1.mem\[23\]\[0\] _0592_ VGND VGND VPWR VPWR _0617_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4221_ clknet_leaf_2_clk _0007_ VGND VGND VPWR VPWR uart_curr_state\[1\] sky130_fd_sc_hd__dfxtp_2
X_2551_ net19 _1944_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__or2_1
X_2482_ _0512_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__clkbuf_1
X_3103_ _1041_ _1042_ VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__and2_1
X_4083_ _1372_ _2055_ _1816_ _0856_ VGND VGND VPWR VPWR _1817_ sky130_fd_sc_hd__a31o_1
XFILLER_0_77_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3034_ _0921_ _0970_ _0971_ _0915_ _0976_ VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__a221o_1
X_4152_ UART1.UART_TX1.index\[3\] UART1.UART_TX1.index\[2\] UART1.UART_TX1.index\[1\]
+ _1861_ VGND VGND VPWR VPWR _1870_ sky130_fd_sc_hd__nand4_1
XFILLER_0_92_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3936_ _2005_ _1692_ _1707_ VGND VGND VPWR VPWR _1708_ sky130_fd_sc_hd__nand3_1
X_3798_ _1607_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__clkbuf_1
X_2749_ net166 _0575_ _0740_ _0569_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__o211a_1
X_2818_ UART1.UART_RX1.clkCount\[2\] UART1.UART_RX1.clkCount\[1\] UART1.UART_RX1.clkCount\[0\]
+ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__and3_1
X_3867_ _1656_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__clkbuf_1
X_4419_ clknet_leaf_11_clk _0198_ VGND VGND VPWR VPWR RAM1.mem\[1\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_94_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_136 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2603_ _0599_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__clkbuf_4
X_3721_ RAM1.mem\[3\]\[0\] _2066_ _1552_ VGND VGND VPWR VPWR _1553_ sky130_fd_sc_hd__mux2_1
X_2534_ net139 _1937_ _0548_ _0545_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__o211a_1
XFILLER_0_2_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3583_ _1461_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__clkbuf_1
X_3652_ RAM1.mem\[19\]\[7\] _0485_ _1493_ VGND VGND VPWR VPWR _1509_ sky130_fd_sc_hd__mux2_1
X_2396_ _0443_ _0444_ _0432_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__mux2_1
X_2465_ RAM1.mem\[11\]\[1\] _0467_ _0490_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__mux2_1
X_4135_ net55 _1856_ _1940_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__o21a_1
X_4204_ net126 net39 _1989_ VGND VGND VPWR VPWR _1911_ sky130_fd_sc_hd__mux2_1
X_4066_ CPU1.RF1.rf\[1\]\[2\] _1791_ _1802_ _1794_ VGND VGND VPWR VPWR _1803_ sky130_fd_sc_hd__o211a_1
X_3017_ CPU1.reg_a_out\[4\] _0903_ _0905_ CPU1.PC1.pc_out\[4\] VGND VGND VPWR VPWR
+ _0961_ sky130_fd_sc_hd__a22o_2
XFILLER_0_3_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3919_ _1688_ _1692_ _1693_ _1951_ VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_56_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2250_ CPU1.instr_reg_out\[3\] _2031_ _2033_ VGND VGND VPWR VPWR _2043_ sky130_fd_sc_hd__or3b_4
XFILLER_0_20_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2181_ UART1.UART_TX1.clkCount\[6\] _1977_ VGND VGND VPWR VPWR _1980_ sky130_fd_sc_hd__or2_1
X_3704_ _0449_ _1545_ _1533_ VGND VGND VPWR VPWR _1546_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3566_ _0446_ _1448_ _1438_ VGND VGND VPWR VPWR _1449_ sky130_fd_sc_hd__mux2_1
X_3497_ _1400_ VGND VGND VPWR VPWR _1401_ sky130_fd_sc_hd__clkbuf_4
X_2517_ _0452_ _0538_ _0524_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__mux2_1
X_3635_ _1497_ _2105_ _1495_ VGND VGND VPWR VPWR _1498_ sky130_fd_sc_hd__mux2_1
X_2379_ _0431_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__clkbuf_4
X_4118_ _0414_ RAM1.mem\[12\]\[7\] _1826_ VGND VGND VPWR VPWR _1842_ sky130_fd_sc_hd__mux2_1
X_2448_ RAM1.mem\[10\]\[7\] _0485_ _0462_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__mux2_1
XFILLER_0_93_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4049_ _0417_ _1788_ _1774_ VGND VGND VPWR VPWR _1789_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold8 step_pulse VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_84_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3351_ _1154_ _1272_ _1274_ _1190_ VGND VGND VPWR VPWR _1275_ sky130_fd_sc_hd__a211o_1
XFILLER_0_52_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3420_ RAM1.mem\[16\]\[7\] RAM1.mem\[17\]\[7\] _1119_ VGND VGND VPWR VPWR _1341_
+ sky130_fd_sc_hd__mux2_1
XTAP_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2233_ UART1.UART_RX1.state\[3\] _2002_ VGND VGND VPWR VPWR _2027_ sky130_fd_sc_hd__and2_1
X_3282_ RAM1.mem\[12\]\[2\] RAM1.mem\[13\]\[2\] _1118_ VGND VGND VPWR VPWR _1208_
+ sky130_fd_sc_hd__mux2_1
X_2164_ net4 _1962_ VGND VGND VPWR VPWR _1963_ sky130_fd_sc_hd__nand2_1
X_2302_ net29 _1941_ _2086_ VGND VGND VPWR VPWR _2087_ sky130_fd_sc_hd__and3_4
XFILLER_0_75_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2997_ _0940_ VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_9_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3549_ _0426_ _0428_ _0430_ _1380_ VGND VGND VPWR VPWR _1437_ sky130_fd_sc_hd__or4_1
X_4598_ clknet_leaf_23_clk _0375_ VGND VGND VPWR VPWR UART1.UART_TX1.clkCount\[9\]
+ sky130_fd_sc_hd__dfxtp_1
X_3618_ _1485_ _0399_ _1477_ VGND VGND VPWR VPWR _1486_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_34_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2920_ CPU1.RF1.rf\[1\]\[5\] _0849_ _0875_ _0853_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__o211a_1
XFILLER_0_57_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2851_ CPU1.curr_state\[1\] _0828_ CPU1.curr_state\[4\] VGND VGND VPWR VPWR _0829_
+ sky130_fd_sc_hd__a21o_2
XFILLER_0_57_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2782_ _0591_ _0769_ _0771_ _0600_ VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__o211a_1
X_4521_ clknet_leaf_16_clk _0298_ VGND VGND VPWR VPWR RAM1.mem\[16\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_4452_ clknet_leaf_13_clk _0231_ VGND VGND VPWR VPWR RAM1.mem\[23\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_3403_ RAM1.mem\[2\]\[6\] RAM1.mem\[3\]\[6\] _1155_ VGND VGND VPWR VPWR _1325_ sky130_fd_sc_hd__mux2_1
X_4383_ clknet_leaf_3_clk _0162_ VGND VGND VPWR VPWR CPU1.mdr_out\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3334_ _1121_ _1257_ VGND VGND VPWR VPWR _1258_ sky130_fd_sc_hd__or2_1
XFILLER_0_0_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3265_ _1149_ _1186_ _1191_ _1162_ VGND VGND VPWR VPWR _1192_ sky130_fd_sc_hd__a31o_1
XTAP_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3196_ _1121_ _1123_ VGND VGND VPWR VPWR _1124_ sky130_fd_sc_hd__or2_1
X_2147_ uart_curr_state\[1\] VGND VGND VPWR VPWR _1948_ sky130_fd_sc_hd__inv_2
XFILLER_0_15_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2216_ UART1.UART_RX1.clkCount\[0\] _1968_ _2009_ _2010_ _2011_ VGND VGND VPWR VPWR
+ _2012_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_72_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3050_ CPU1.reg_b_out\[3\] _2051_ VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__or2_1
XFILLER_0_89_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2903_ CPU1.reg_a_out\[1\] _0847_ _0860_ _0862_ _0623_ VGND VGND VPWR VPWR _0123_
+ sky130_fd_sc_hd__o221a_1
X_3883_ UART1.UART_RX1.state\[3\] _2007_ _1931_ VGND VGND VPWR VPWR _1667_ sky130_fd_sc_hd__o21a_1
X_3952_ net144 net137 _1710_ VGND VGND VPWR VPWR _1717_ sky130_fd_sc_hd__mux2_1
X_4504_ clknet_leaf_8_clk _0283_ VGND VGND VPWR VPWR RAM1.mem\[7\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2765_ RAM1.mem\[16\]\[6\] RAM1.mem\[17\]\[6\] _0494_ VGND VGND VPWR VPWR _0756_
+ sky130_fd_sc_hd__mux2_1
X_2696_ _0688_ _0689_ _0579_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__mux2_1
X_2834_ _0814_ _0815_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3317_ RAM1.mem\[0\]\[3\] _1157_ _2078_ _1241_ VGND VGND VPWR VPWR _1242_ sky130_fd_sc_hd__o211a_1
X_4297_ clknet_leaf_3_clk _0088_ VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__dfxtp_2
X_4366_ clknet_leaf_2_clk _0145_ VGND VGND VPWR VPWR CPU1.PC1.pc_out\[7\] sky130_fd_sc_hd__dfxtp_1
X_4435_ clknet_leaf_17_clk _0214_ VGND VGND VPWR VPWR RAM1.mem\[17\]\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3179_ _1108_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3248_ RAM1.mem\[10\]\[1\] RAM1.mem\[11\]\[1\] _1135_ VGND VGND VPWR VPWR _1175_
+ sky130_fd_sc_hd__mux2_1
XPHY_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_63_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2550_ net120 _0550_ _0556_ _0557_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__o211a_1
X_2481_ _0511_ _0411_ _0499_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__mux2_1
X_4220_ clknet_leaf_25_clk net11 VGND VGND VPWR VPWR uart_curr_state\[0\] sky130_fd_sc_hd__dfxtp_1
X_4151_ UART1.UART_TX1.index\[2\] UART1.UART_TX1.index\[1\] _1861_ UART1.UART_TX1.index\[3\]
+ VGND VGND VPWR VPWR _1869_ sky130_fd_sc_hd__a31o_1
X_4082_ CPU1.RF1.rf\[3\]\[5\] CPU1.RF1.rf\[2\]\[5\] _1790_ VGND VGND VPWR VPWR _1816_
+ sky130_fd_sc_hd__mux2_1
X_3102_ net48 _1040_ _1038_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__nand3_1
X_3033_ _0901_ _0911_ _0975_ _0894_ VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__o211a_1
XFILLER_0_53_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_207 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3935_ _2004_ _1701_ VGND VGND VPWR VPWR _1707_ sky130_fd_sc_hd__nor2_1
X_3866_ _1655_ _2110_ _1651_ VGND VGND VPWR VPWR _1656_ sky130_fd_sc_hd__mux2_1
X_4418_ clknet_leaf_11_clk _0197_ VGND VGND VPWR VPWR RAM1.mem\[1\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_82_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3797_ _0449_ _1606_ _1594_ VGND VGND VPWR VPWR _1607_ sky130_fd_sc_hd__mux2_1
X_2679_ net41 _0575_ _0672_ _0673_ _0623_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__o221a_1
X_2748_ CPU1.PC1.pc_out\[5\] _1926_ _0739_ _1923_ _0647_ VGND VGND VPWR VPWR _0740_
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_41_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2817_ _0803_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__clkbuf_1
X_4349_ clknet_leaf_1_clk _0004_ VGND VGND VPWR VPWR CPU1.curr_state\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_83_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3720_ _1529_ _0489_ VGND VGND VPWR VPWR _1552_ sky130_fd_sc_hd__nor2_4
XFILLER_0_59_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2602_ _1919_ _2095_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__nand2_4
X_2533_ net27 _0540_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__or2_1
X_3651_ _1508_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3582_ _1460_ _2105_ _1458_ VGND VGND VPWR VPWR _1461_ sky130_fd_sc_hd__mux2_1
X_2395_ _0396_ RAM1.mem\[0\]\[4\] _0423_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2464_ _0500_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__clkbuf_1
X_4203_ net132 _1909_ _1910_ _0623_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__o211a_1
X_4134_ _1933_ net57 VGND VGND VPWR VPWR _1856_ sky130_fd_sc_hd__nor2_1
X_4065_ CPU1.RF1.rf\[0\]\[2\] _1792_ VGND VGND VPWR VPWR _1802_ sky130_fd_sc_hd__or2_1
XFILLER_0_64_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3016_ _0913_ _0907_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__nand2_1
X_3849_ _0446_ _1643_ _1633_ VGND VGND VPWR VPWR _1644_ sky130_fd_sc_hd__mux2_1
X_3918_ _2005_ _1692_ _1688_ VGND VGND VPWR VPWR _1693_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_22_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_22_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_100_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2180_ net8 _1956_ VGND VGND VPWR VPWR _1979_ sky130_fd_sc_hd__xor2_2
XFILLER_0_18_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_13_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_13_clk sky130_fd_sc_hd__clkbuf_16
X_3703_ RAM1.mem\[2\]\[6\] _0482_ _1530_ VGND VGND VPWR VPWR _1545_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3634_ RAM1.mem\[19\]\[1\] _0467_ _1493_ VGND VGND VPWR VPWR _1497_ sky130_fd_sc_hd__mux2_1
X_3565_ _0402_ RAM1.mem\[1\]\[5\] _1435_ VGND VGND VPWR VPWR _1448_ sky130_fd_sc_hd__mux2_1
X_2516_ RAM1.mem\[22\]\[7\] _0485_ _0519_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__mux2_1
X_2447_ _0413_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__buf_4
X_3496_ _0522_ _1380_ VGND VGND VPWR VPWR _1400_ sky130_fd_sc_hd__or2_1
XFILLER_0_59_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2378_ _0426_ _2098_ _0428_ _0430_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__or4_1
X_4048_ _0485_ RAM1.mem\[13\]\[7\] _1771_ VGND VGND VPWR VPWR _1788_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4117_ _1841_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_61_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold9 _0011_ VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_69_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3350_ RAM1.mem\[6\]\[4\] _0459_ _1115_ _1273_ VGND VGND VPWR VPWR _1274_ sky130_fd_sc_hd__o211a_1
X_2301_ _2085_ VGND VGND VPWR VPWR _2086_ sky130_fd_sc_hd__buf_4
XTAP_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_2_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_2_clk sky130_fd_sc_hd__clkbuf_16
X_2232_ _2024_ _2026_ _1952_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__a21oi_1
X_2163_ net3 net1 net2 VGND VGND VPWR VPWR _1962_ sky130_fd_sc_hd__or3_1
X_3281_ _1134_ _1204_ _1206_ _2069_ VGND VGND VPWR VPWR _1207_ sky130_fd_sc_hd__a211o_2
XFILLER_0_75_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2996_ _2062_ _0932_ _0936_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__or3_1
XFILLER_0_28_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4597_ clknet_leaf_24_clk _0374_ VGND VGND VPWR VPWR UART1.UART_TX1.clkCount\[8\]
+ sky130_fd_sc_hd__dfxtp_1
X_3617_ _0396_ RAM1.mem\[17\]\[4\] _1475_ VGND VGND VPWR VPWR _1485_ sky130_fd_sc_hd__mux2_1
XFILLER_0_101_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3548_ _2067_ RAM1.mem\[1\]\[0\] _1435_ VGND VGND VPWR VPWR _1436_ sky130_fd_sc_hd__mux2_1
X_3479_ _1387_ _0393_ _1381_ VGND VGND VPWR VPWR _1388_ sky130_fd_sc_hd__mux2_1
XFILLER_0_81_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2850_ _2041_ _2044_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__or2_1
XFILLER_0_57_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4451_ clknet_leaf_13_clk _0230_ VGND VGND VPWR VPWR RAM1.mem\[23\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_2781_ _0595_ _0770_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__or2_1
X_4520_ clknet_leaf_16_clk _0297_ VGND VGND VPWR VPWR RAM1.mem\[16\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3264_ _1154_ _1187_ _1189_ _1190_ VGND VGND VPWR VPWR _1191_ sky130_fd_sc_hd__a211o_1
X_4382_ clknet_leaf_4_clk _0161_ VGND VGND VPWR VPWR CPU1.mdr_out\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3402_ _1128_ _1321_ _1323_ _1131_ VGND VGND VPWR VPWR _1324_ sky130_fd_sc_hd__a211o_1
XTAP_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3333_ RAM1.mem\[18\]\[4\] RAM1.mem\[19\]\[4\] _1122_ VGND VGND VPWR VPWR _1257_
+ sky130_fd_sc_hd__mux2_1
XTAP_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3195_ RAM1.mem\[22\]\[0\] RAM1.mem\[23\]\[0\] _1122_ VGND VGND VPWR VPWR _1123_
+ sky130_fd_sc_hd__mux2_1
X_2215_ UART1.UART_RX1.clkCount\[1\] _1967_ VGND VGND VPWR VPWR _2011_ sky130_fd_sc_hd__xnor2_1
X_2146_ _1947_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__clkbuf_1
X_2979_ _2033_ _2037_ _2040_ _2060_ _0923_ VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__o311a_4
XFILLER_0_48_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xsplit1 _0912_ VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__clkbuf_2
X_2902_ _0852_ _2056_ _0861_ _0857_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__a31o_1
X_3882_ _1666_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__clkbuf_1
X_2833_ UART1.UART_RX1.clkCount\[6\] _0811_ _0799_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__o21ai_1
X_3951_ net121 VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__clkbuf_1
X_4503_ clknet_leaf_8_clk _0282_ VGND VGND VPWR VPWR RAM1.mem\[6\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_2764_ _0744_ _0747_ _0751_ _0754_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__o22a_1
X_2695_ RAM1.mem\[18\]\[3\] RAM1.mem\[19\]\[3\] _0496_ VGND VGND VPWR VPWR _0689_
+ sky130_fd_sc_hd__mux2_1
X_4434_ clknet_leaf_18_clk _0213_ VGND VGND VPWR VPWR RAM1.mem\[17\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_3316_ RAM1.mem\[1\]\[3\] _1158_ VGND VGND VPWR VPWR _1241_ sky130_fd_sc_hd__or2_1
X_4365_ clknet_leaf_2_clk _0144_ VGND VGND VPWR VPWR CPU1.PC1.pc_out\[6\] sky130_fd_sc_hd__dfxtp_1
X_3247_ _1117_ _1171_ _1173_ _1132_ VGND VGND VPWR VPWR _1174_ sky130_fd_sc_hd__o211a_1
X_4296_ clknet_leaf_2_clk _0087_ VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__dfxtp_1
XTAP_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3178_ _1946_ _1107_ VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__and2_1
XPHY_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2129_ net11 _1934_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__nor2_1
XPHY_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2480_ RAM1.mem\[11\]\[6\] _0482_ _0490_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4081_ CPU1.RF1.rf\[1\]\[5\] _1791_ _1814_ _1794_ VGND VGND VPWR VPWR _1815_ sky130_fd_sc_hd__o211a_1
X_3101_ net48 _1038_ _1040_ VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__a21o_1
X_4150_ _2058_ _1868_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__nor2_1
X_3032_ _0901_ _0974_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3796_ _0482_ RAM1.mem\[5\]\[6\] _1591_ VGND VGND VPWR VPWR _1606_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3865_ _2108_ RAM1.mem\[16\]\[2\] _1649_ VGND VGND VPWR VPWR _1655_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2816_ _0799_ _0801_ _0802_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__and3_1
X_3934_ _1692_ _1702_ _1705_ VGND VGND VPWR VPWR _1706_ sky130_fd_sc_hd__a21o_1
XFILLER_0_18_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4417_ clknet_leaf_11_clk _0196_ VGND VGND VPWR VPWR RAM1.mem\[1\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2678_ CPU1.PC1.pc_out\[2\] _1926_ _0575_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__a21bo_1
X_2747_ _0521_ _0725_ _0732_ _0738_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__a31o_1
X_4279_ clknet_leaf_1_clk _0070_ VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__dfxtp_2
X_4348_ clknet_leaf_1_clk net62 VGND VGND VPWR VPWR CPU1.ir_load sky130_fd_sc_hd__dfxtp_4
XFILLER_0_76_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3650_ _1507_ _0411_ _1495_ VGND VGND VPWR VPWR _1508_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2532_ net120 _1937_ _0547_ _0545_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__o211a_1
X_2463_ _0491_ _2088_ _0499_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__mux2_1
X_3581_ RAM1.mem\[18\]\[1\] _0467_ _1455_ VGND VGND VPWR VPWR _1460_ sky130_fd_sc_hd__mux2_1
X_4202_ _1873_ _1906_ net132 _1874_ VGND VGND VPWR VPWR _1910_ sky130_fd_sc_hd__o211ai_1
X_2601_ _0595_ _0597_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__or2_1
X_4064_ CPU1.reg_b_out\[1\] _0847_ _1799_ _1801_ _0879_ VGND VGND VPWR VPWR _0345_
+ sky130_fd_sc_hd__o221a_1
X_2394_ _0398_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__clkbuf_4
X_3015_ _0953_ _0955_ _0956_ _0957_ _0958_ VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__a311o_1
X_4133_ _1855_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3848_ RAM1.mem\[7\]\[5\] _0401_ _1630_ VGND VGND VPWR VPWR _1643_ sky130_fd_sc_hd__mux2_1
X_3779_ _0419_ _1592_ _1594_ VGND VGND VPWR VPWR _1595_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3917_ _1691_ VGND VGND VPWR VPWR _1692_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_96_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3702_ _1544_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_50_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3633_ _1496_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__clkbuf_1
X_3564_ _1447_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__clkbuf_1
X_3495_ _2067_ RAM1.mem\[21\]\[0\] _1398_ VGND VGND VPWR VPWR _1399_ sky130_fd_sc_hd__mux2_1
X_2515_ _0537_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__clkbuf_1
X_2446_ _0484_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__clkbuf_1
X_2377_ _0429_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__buf_2
XFILLER_0_38_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4047_ _1787_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__clkbuf_1
X_4116_ _1840_ _0410_ _1828_ VGND VGND VPWR VPWR _1841_ sky130_fd_sc_hd__mux2_1
XFILLER_0_91_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2300_ net26 net25 _2083_ _2084_ VGND VGND VPWR VPWR _2085_ sky130_fd_sc_hd__and4b_1
XFILLER_0_29_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2231_ _2025_ _2016_ _2022_ VGND VGND VPWR VPWR _2026_ sky130_fd_sc_hd__or3_1
X_3280_ RAM1.mem\[8\]\[2\] _1138_ _1139_ _1205_ VGND VGND VPWR VPWR _1206_ sky130_fd_sc_hd__o211a_1
XFILLER_0_45_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2162_ net5 _1954_ VGND VGND VPWR VPWR _1961_ sky130_fd_sc_hd__xor2_2
XFILLER_0_61_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2995_ _2058_ _0939_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__nor2_1
XFILLER_0_28_152 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3547_ _0422_ _1377_ VGND VGND VPWR VPWR _1435_ sky130_fd_sc_hd__nand2_4
XFILLER_0_43_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_43_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3616_ _1484_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4596_ clknet_leaf_25_clk _0373_ VGND VGND VPWR VPWR UART1.UART_TX1.clkCount\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_101_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2429_ _0471_ _0387_ _0465_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__mux2_1
X_3478_ _0390_ RAM1.mem\[9\]\[3\] _1378_ VGND VGND VPWR VPWR _1387_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_217 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4450_ clknet_leaf_13_clk _0229_ VGND VGND VPWR VPWR RAM1.mem\[23\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_4381_ clknet_leaf_4_clk _0160_ VGND VGND VPWR VPWR CPU1.mdr_out\[5\] sky130_fd_sc_hd__dfxtp_1
X_3401_ RAM1.mem\[14\]\[6\] _1135_ _1115_ _1322_ VGND VGND VPWR VPWR _1323_ sky130_fd_sc_hd__o211a_1
X_2780_ RAM1.mem\[8\]\[7\] RAM1.mem\[9\]\[7\] _0592_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__mux2_1
XFILLER_0_40_147 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_31_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3263_ _0515_ VGND VGND VPWR VPWR _1190_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_56_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3194_ _0458_ VGND VGND VPWR VPWR _1122_ sky130_fd_sc_hd__buf_4
XTAP_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2214_ UART1.UART_RX1.clkCount\[0\] _1968_ UART1.UART_RX1.clkCount\[9\] VGND VGND
+ VPWR VPWR _2010_ sky130_fd_sc_hd__o21bai_1
X_3332_ RAM1.mem\[16\]\[4\] RAM1.mem\[17\]\[4\] _1119_ VGND VGND VPWR VPWR _1256_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2145_ _1946_ _1945_ VGND VGND VPWR VPWR _1947_ sky130_fd_sc_hd__and2_1
XFILLER_0_63_206 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2978_ _2037_ _2042_ VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__or2_2
X_4579_ clknet_leaf_22_clk _0356_ VGND VGND VPWR VPWR RAM1.mem\[12\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_98_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold90 _1713_ VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__dlygate4sd3_1
X_3950_ UART1.RX_dataOut\[5\] net115 _1710_ VGND VGND VPWR VPWR _1716_ sky130_fd_sc_hd__mux2_1
X_2901_ CPU1.RF1.rf\[3\]\[1\] CPU1.RF1.rf\[2\]\[1\] _0849_ VGND VGND VPWR VPWR _0861_
+ sky130_fd_sc_hd__mux2_1
X_2763_ _0577_ _0752_ _0753_ _0425_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__a31o_1
X_3881_ _1665_ _0416_ _1651_ VGND VGND VPWR VPWR _1666_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2832_ UART1.UART_RX1.clkCount\[6\] _0811_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__and2_1
X_4502_ clknet_leaf_8_clk _0281_ VGND VGND VPWR VPWR RAM1.mem\[6\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_4364_ clknet_leaf_2_clk _0143_ VGND VGND VPWR VPWR CPU1.PC1.pc_out\[5\] sky130_fd_sc_hd__dfxtp_1
X_4433_ clknet_leaf_17_clk _0212_ VGND VGND VPWR VPWR RAM1.mem\[17\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_2694_ RAM1.mem\[16\]\[3\] RAM1.mem\[17\]\[3\] _0496_ VGND VGND VPWR VPWR _0688_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3315_ RAM1.mem\[2\]\[3\] RAM1.mem\[3\]\[3\] _0459_ VGND VGND VPWR VPWR _1240_ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3177_ CPU1.alu_reg_out\[5\] _1055_ _0903_ VGND VGND VPWR VPWR _1107_ sky130_fd_sc_hd__mux2_1
X_4295_ clknet_leaf_22_clk _0086_ VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__dfxtp_1
XTAP_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3246_ _1128_ _1172_ VGND VGND VPWR VPWR _1173_ sky130_fd_sc_hd__or2_1
XTAP_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2128_ _1933_ net108 net140 VGND VGND VPWR VPWR _1934_ sky130_fd_sc_hd__a21oi_1
XPHY_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4080_ CPU1.RF1.rf\[0\]\[5\] _1792_ VGND VGND VPWR VPWR _1814_ sky130_fd_sc_hd__or2_1
X_3100_ CPU1.reg_b_out\[5\] _2051_ _1039_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__o21a_1
X_3031_ _0913_ _0961_ _0973_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_37_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_76 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3933_ net164 VGND VGND VPWR VPWR _1705_ sky130_fd_sc_hd__inv_2
X_3795_ _1605_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__clkbuf_1
X_2746_ _2092_ _0735_ _0737_ _0430_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__o211a_1
X_3864_ _1654_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__clkbuf_1
X_2815_ UART1.UART_RX1.clkCount\[1\] UART1.UART_RX1.clkCount\[0\] VGND VGND VPWR VPWR
+ _0802_ sky130_fd_sc_hd__or2_1
XFILLER_0_78_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4347_ clknet_leaf_4_clk _0003_ VGND VGND VPWR VPWR CPU1.curr_state\[2\] sky130_fd_sc_hd__dfxtp_2
X_4416_ clknet_leaf_10_clk _0195_ VGND VGND VPWR VPWR RAM1.mem\[1\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_68_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2677_ _1923_ _0671_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__and2_1
X_3229_ _0458_ VGND VGND VPWR VPWR _1157_ sky130_fd_sc_hd__clkbuf_4
X_4278_ clknet_leaf_0_clk _0069_ VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_68_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3580_ _1459_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__clkbuf_1
X_2600_ RAM1.mem\[8\]\[0\] RAM1.mem\[9\]\[0\] _0596_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__mux2_1
X_2393_ _0442_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2531_ net26 _0540_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__or2_1
X_4201_ _1873_ _1906_ VGND VGND VPWR VPWR _1909_ sky130_fd_sc_hd__and2b_1
X_2462_ _2094_ _0498_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__nor2_4
X_4063_ _1372_ _2055_ _1800_ _0857_ VGND VGND VPWR VPWR _1801_ sky130_fd_sc_hd__a31o_1
X_3014_ _0900_ _0917_ _0915_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__o21a_1
X_4132_ _1951_ _1854_ VGND VGND VPWR VPWR _1855_ sky130_fd_sc_hd__or2_1
XFILLER_0_3_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3916_ _2003_ _0798_ _1690_ VGND VGND VPWR VPWR _1691_ sky130_fd_sc_hd__and3_1
XFILLER_0_89_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3847_ _1642_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__clkbuf_1
X_3778_ _1593_ VGND VGND VPWR VPWR _1594_ sky130_fd_sc_hd__clkbuf_4
X_2729_ RAM1.mem\[12\]\[5\] RAM1.mem\[13\]\[5\] _0612_ VGND VGND VPWR VPWR _0721_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_96_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_18_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3563_ _0443_ _1446_ _1438_ VGND VGND VPWR VPWR _1447_ sky130_fd_sc_hd__mux2_1
X_3701_ _0446_ _1543_ _1533_ VGND VGND VPWR VPWR _1544_ sky130_fd_sc_hd__mux2_1
XFILLER_0_50_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3632_ _1494_ _2088_ _1495_ VGND VGND VPWR VPWR _1496_ sky130_fd_sc_hd__mux2_1
X_3494_ _1397_ _1377_ VGND VGND VPWR VPWR _1398_ sky130_fd_sc_hd__nand2_4
X_2514_ _0449_ _0536_ _0524_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__mux2_1
X_2376_ net17 _1919_ _2090_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__and3_2
X_2445_ _0483_ _0411_ _0465_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4115_ _0408_ RAM1.mem\[12\]\[6\] _1826_ VGND VGND VPWR VPWR _1840_ sky130_fd_sc_hd__mux2_1
X_4046_ _0411_ _1786_ _1774_ VGND VGND VPWR VPWR _1787_ sky130_fd_sc_hd__mux2_1
XFILLER_0_34_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2230_ net171 VGND VGND VPWR VPWR _2025_ sky130_fd_sc_hd__inv_2
X_2161_ _1957_ _1959_ VGND VGND VPWR VPWR _1960_ sky130_fd_sc_hd__and2_2
X_2994_ _0890_ _0928_ _0937_ _0938_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__o31a_1
XFILLER_0_28_164 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_35 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3546_ _1434_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_189 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3615_ _1483_ _0393_ _1477_ VGND VGND VPWR VPWR _1484_ sky130_fd_sc_hd__mux2_1
X_4595_ clknet_leaf_24_clk _0372_ VGND VGND VPWR VPWR UART1.UART_TX1.clkCount\[6\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_98_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2359_ _2049_ CPU1.reg_a_out\[7\] _2065_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__and3_2
XFILLER_0_50_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2428_ RAM1.mem\[10\]\[2\] _0470_ _0462_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__mux2_1
X_3477_ _1386_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__clkbuf_1
X_4029_ _1775_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_229 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_65_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4380_ clknet_leaf_7_clk _0159_ VGND VGND VPWR VPWR CPU1.mdr_out\[4\] sky130_fd_sc_hd__dfxtp_1
X_3331_ _1134_ _1252_ _1254_ _1125_ VGND VGND VPWR VPWR _1255_ sky130_fd_sc_hd__o211a_1
X_3400_ RAM1.mem\[15\]\[6\] _2075_ VGND VGND VPWR VPWR _1322_ sky130_fd_sc_hd__or2_1
XFILLER_0_40_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3262_ RAM1.mem\[6\]\[1\] _1157_ _1115_ _1188_ VGND VGND VPWR VPWR _1189_ sky130_fd_sc_hd__o211a_1
XTAP_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3193_ _2078_ VGND VGND VPWR VPWR _1121_ sky130_fd_sc_hd__buf_2
XTAP_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2213_ UART1.UART_RX1.clkCount\[2\] _1964_ VGND VGND VPWR VPWR _2009_ sky130_fd_sc_hd__xnor2_1
X_2144_ _1939_ VGND VGND VPWR VPWR _1946_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_72_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2977_ net173 _0900_ VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__nor2_1
XFILLER_0_63_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3529_ _2108_ RAM1.mem\[20\]\[2\] _1417_ VGND VGND VPWR VPWR _1423_ sky130_fd_sc_hd__mux2_1
X_4578_ clknet_leaf_21_clk _0355_ VGND VGND VPWR VPWR RAM1.mem\[12\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2900_ CPU1.RF1.rf\[1\]\[1\] _0849_ _0859_ _0853_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__o211a_1
Xhold80 UART1.UART_TX1.state\[2\] VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__dlygate4sd3_1
Xhold91 UART1.RX_dataOut\[6\] VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4501_ clknet_leaf_6_clk _0280_ VGND VGND VPWR VPWR RAM1.mem\[6\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_2762_ RAM1.mem\[6\]\[6\] _0492_ _0494_ RAM1.mem\[7\]\[6\] _0588_ VGND VGND VPWR
+ VPWR _0753_ sky130_fd_sc_hd__a221o_1
XFILLER_0_45_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3880_ _0414_ RAM1.mem\[16\]\[7\] _1649_ VGND VGND VPWR VPWR _1665_ sky130_fd_sc_hd__mux2_1
X_2831_ _0813_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__clkbuf_1
X_2693_ _0580_ _0681_ _0682_ _0686_ _0426_ VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__a311o_1
X_4363_ clknet_leaf_3_clk _0142_ VGND VGND VPWR VPWR CPU1.PC1.pc_out\[4\] sky130_fd_sc_hd__dfxtp_2
X_4294_ clknet_leaf_2_clk _0085_ VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__dfxtp_1
X_3314_ _1128_ _1236_ _1238_ _1131_ VGND VGND VPWR VPWR _1239_ sky130_fd_sc_hd__a211o_2
XTAP_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4432_ clknet_leaf_18_clk _0211_ VGND VGND VPWR VPWR RAM1.mem\[17\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_3176_ net73 _1094_ _1106_ _1092_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__o211a_1
XTAP_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3245_ RAM1.mem\[18\]\[1\] RAM1.mem\[19\]\[1\] _1122_ VGND VGND VPWR VPWR _1172_
+ sky130_fd_sc_hd__mux2_1
XTAP_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2127_ UART1.TX_done VGND VGND VPWR VPWR _1933_ sky130_fd_sc_hd__inv_2
XTAP_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_184 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_88_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_207 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3030_ _0910_ _0972_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__or2_1
XFILLER_0_53_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3863_ _1653_ _2104_ _1651_ VGND VGND VPWR VPWR _1654_ sky130_fd_sc_hd__mux2_1
X_3932_ _1704_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__clkbuf_1
X_3794_ _0446_ _1604_ _1594_ VGND VGND VPWR VPWR _1605_ sky130_fd_sc_hd__mux2_1
X_2745_ _0615_ _0736_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__or2_1
X_2676_ _0521_ _0655_ _0662_ _0670_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__a31o_1
XFILLER_0_41_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2814_ UART1.UART_RX1.clkCount\[1\] UART1.UART_RX1.clkCount\[0\] VGND VGND VPWR VPWR
+ _0801_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4415_ clknet_leaf_14_clk _0194_ VGND VGND VPWR VPWR RAM1.mem\[20\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_4346_ clknet_leaf_1_clk _0010_ VGND VGND VPWR VPWR CPU1.curr_state\[1\] sky130_fd_sc_hd__dfxtp_2
X_4277_ clknet_leaf_1_clk _0068_ VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__dfxtp_1
X_3228_ RAM1.mem\[4\]\[0\] RAM1.mem\[5\]\[0\] _1155_ VGND VGND VPWR VPWR _1156_ sky130_fd_sc_hd__mux2_1
X_3159_ _0903_ _0928_ VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__nand2_1
XFILLER_0_99_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_25_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_25_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_82_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2530_ net118 _1937_ _0546_ _0545_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__o211a_1
X_2392_ _0440_ _0441_ _0432_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4131_ net47 UART1.UART_TX1.state\[0\] UART1.UART_TX1.state\[2\] _1850_ _1853_ VGND
+ VGND VPWR VPWR _1854_ sky130_fd_sc_hd__o32a_1
X_2461_ net14 _2086_ _0497_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__nand3_4
X_4200_ _1908_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__clkbuf_1
X_4062_ CPU1.RF1.rf\[3\]\[1\] CPU1.RF1.rf\[2\]\[1\] _1791_ VGND VGND VPWR VPWR _1800_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_64_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3013_ _0900_ _0917_ _0923_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__a21oi_1
X_3846_ _0443_ _1641_ _1633_ VGND VGND VPWR VPWR _1642_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_16_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_16_clk sky130_fd_sc_hd__clkbuf_16
X_3915_ UART1.UART_RX1.state\[3\] UART1.UART_RX1.state\[0\] UART1.UART_RX1.state\[1\]
+ _1689_ VGND VGND VPWR VPWR _1690_ sky130_fd_sc_hd__o31a_1
XFILLER_0_13_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3777_ _0425_ _0615_ _0429_ _1380_ VGND VGND VPWR VPWR _1593_ sky130_fd_sc_hd__or4_1
X_2659_ _0605_ _0651_ _0653_ _0599_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__o211a_1
X_2728_ RAM1.mem\[14\]\[5\] _0586_ _0583_ RAM1.mem\[15\]\[5\] _0605_ VGND VGND VPWR
+ VPWR _0720_ sky130_fd_sc_hd__a221o_1
X_4329_ clknet_leaf_6_clk _0117_ VGND VGND VPWR VPWR CPU1.RF1.rf\[1\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_100_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3700_ RAM1.mem\[2\]\[5\] _0479_ _1530_ VGND VGND VPWR VPWR _1543_ sky130_fd_sc_hd__mux2_1
XFILLER_0_50_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3562_ _0396_ RAM1.mem\[1\]\[4\] _1435_ VGND VGND VPWR VPWR _1446_ sky130_fd_sc_hd__mux2_1
X_3493_ _0456_ _1162_ _1149_ VGND VGND VPWR VPWR _1397_ sky130_fd_sc_hd__and3_2
X_2513_ RAM1.mem\[22\]\[6\] _0482_ _0519_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__mux2_1
X_3631_ _0498_ _1457_ VGND VGND VPWR VPWR _1495_ sky130_fd_sc_hd__nor2_4
Xclkbuf_leaf_5_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_5_clk sky130_fd_sc_hd__clkbuf_16
X_2375_ _0427_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__buf_4
X_4114_ _1839_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__clkbuf_1
X_2444_ RAM1.mem\[10\]\[6\] _0482_ _0462_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__mux2_1
X_4045_ _0482_ RAM1.mem\[13\]\[6\] _1771_ VGND VGND VPWR VPWR _1786_ sky130_fd_sc_hd__mux2_1
X_3829_ _1629_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_61_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2160_ net8 _1956_ net9 VGND VGND VPWR VPWR _1959_ sky130_fd_sc_hd__o21ai_1
Xmax_cap1 _2038_ VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__buf_1
XFILLER_0_0_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2993_ net13 _0936_ _0937_ CPU1.PC1.pc_out\[0\] VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3614_ _0390_ RAM1.mem\[17\]\[3\] _1475_ VGND VGND VPWR VPWR _1483_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3545_ _1433_ _0417_ _1419_ VGND VGND VPWR VPWR _1434_ sky130_fd_sc_hd__mux2_1
X_2427_ _2107_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__buf_4
XFILLER_0_31_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4594_ clknet_leaf_24_clk _0371_ VGND VGND VPWR VPWR UART1.UART_TX1.clkCount\[5\]
+ sky130_fd_sc_hd__dfxtp_1
X_3476_ _1385_ _0387_ _1381_ VGND VGND VPWR VPWR _1386_ sky130_fd_sc_hd__mux2_1
XFILLER_0_86_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2289_ CPU1.ir_load CPU1.PC1.pc_out\[0\] net52 CPU1.reg_b_out\[0\] VGND VGND VPWR
+ VPWR _2074_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4028_ _2088_ _1772_ _1774_ VGND VGND VPWR VPWR _1775_ sky130_fd_sc_hd__mux2_1
X_2358_ _0412_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_100_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3330_ _1154_ _1253_ VGND VGND VPWR VPWR _1254_ sky130_fd_sc_hd__or2_1
XTAP_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3261_ RAM1.mem\[7\]\[1\] _1158_ VGND VGND VPWR VPWR _1188_ sky130_fd_sc_hd__or2_1
XTAP_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_11 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3192_ RAM1.mem\[20\]\[0\] RAM1.mem\[21\]\[0\] _1119_ VGND VGND VPWR VPWR _1120_
+ sky130_fd_sc_hd__mux2_1
X_2212_ _2007_ UART1.UART_RX1.regIn VGND VGND VPWR VPWR _2008_ sky130_fd_sc_hd__or2_1
X_2143_ _1941_ _1942_ _1943_ _1945_ _1940_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__o41a_1
XFILLER_0_71_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2976_ _2037_ _2042_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__nor2_2
X_4577_ clknet_leaf_21_clk _0354_ VGND VGND VPWR VPWR RAM1.mem\[12\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_3459_ _1365_ _1372_ _1366_ _1373_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__o211a_1
X_3528_ _1422_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_54_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_190 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold70 UART1.UART_TX1.packet\[4\] VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__dlygate4sd3_1
Xhold81 UART1.UART_RX1.dataOut\[4\] VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__dlygate4sd3_1
Xhold92 UART1.RX_dataOut\[7\] VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__buf_1
XFILLER_0_89_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2830_ _0811_ _0812_ _0799_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__and3b_1
X_2692_ _0591_ _0683_ _0685_ _0600_ VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__o211a_1
X_4500_ clknet_leaf_7_clk _0279_ VGND VGND VPWR VPWR RAM1.mem\[6\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_2761_ RAM1.mem\[2\]\[6\] _0492_ _0596_ RAM1.mem\[3\]\[6\] _0427_ VGND VGND VPWR
+ VPWR _0752_ sky130_fd_sc_hd__a221o_1
X_4431_ clknet_leaf_18_clk _0210_ VGND VGND VPWR VPWR RAM1.mem\[18\]\[7\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_1 _0390_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4362_ clknet_leaf_3_clk _0141_ VGND VGND VPWR VPWR CPU1.PC1.pc_out\[3\] sky130_fd_sc_hd__dfxtp_2
X_3244_ RAM1.mem\[16\]\[1\] RAM1.mem\[17\]\[1\] _1119_ VGND VGND VPWR VPWR _1171_
+ sky130_fd_sc_hd__mux2_1
X_4293_ clknet_leaf_0_clk _0084_ VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__dfxtp_2
X_3313_ RAM1.mem\[14\]\[3\] _1144_ _1145_ _1237_ VGND VGND VPWR VPWR _1238_ sky130_fd_sc_hd__o211a_1
XTAP_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3175_ _1094_ _1035_ VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__nand2_1
XTAP_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2126_ net11 _1932_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__nor2_1
XPHY_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2959_ _2028_ _2036_ CPU1.ir_load VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__a21o_2
XPHY_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3862_ _2102_ RAM1.mem\[16\]\[1\] _1649_ VGND VGND VPWR VPWR _1653_ sky130_fd_sc_hd__mux2_1
X_3931_ _2063_ _1700_ _1703_ VGND VGND VPWR VPWR _1704_ sky130_fd_sc_hd__and3_1
X_2813_ _0800_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__clkbuf_1
X_3793_ _0479_ RAM1.mem\[5\]\[5\] _1591_ VGND VGND VPWR VPWR _1604_ sky130_fd_sc_hd__mux2_1
XFILLER_0_75_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2744_ RAM1.mem\[20\]\[5\] RAM1.mem\[21\]\[5\] RAM1.mem\[22\]\[5\] RAM1.mem\[23\]\[5\]
+ _0495_ _0578_ VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__mux4_1
X_4414_ clknet_leaf_14_clk _0193_ VGND VGND VPWR VPWR RAM1.mem\[20\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_2675_ _2092_ _0665_ _0669_ _0430_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__o211a_1
X_3227_ _0458_ VGND VGND VPWR VPWR _1155_ sky130_fd_sc_hd__buf_4
X_4345_ clknet_leaf_1_clk _0009_ VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__dfxtp_1
X_4276_ clknet_leaf_0_clk _0067_ VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_76_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3089_ _1029_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__inv_2
X_3158_ _1093_ _1094_ VGND VGND VPWR VPWR _1095_ sky130_fd_sc_hd__or2_1
XFILLER_0_91_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2460_ _0496_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__buf_4
X_2391_ _0390_ RAM1.mem\[0\]\[3\] _0423_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__mux2_1
X_4061_ CPU1.RF1.rf\[1\]\[1\] _1791_ _1798_ _1794_ VGND VGND VPWR VPWR _1799_ sky130_fd_sc_hd__o211a_1
X_4130_ UART1.UART_TX1.index\[3\] _1844_ _1851_ _1852_ VGND VGND VPWR VPWR _1853_
+ sky130_fd_sc_hd__a31o_1
Xwire48 _1018_ VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_58_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3012_ _2029_ _2041_ _0892_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__and3_2
X_3776_ _0455_ RAM1.mem\[5\]\[0\] _1591_ VGND VGND VPWR VPWR _1592_ sky130_fd_sc_hd__mux2_1
X_3845_ RAM1.mem\[7\]\[4\] _0395_ _1630_ VGND VGND VPWR VPWR _1641_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3914_ UART1.UART_RX1.index\[3\] UART1.UART_RX1.state\[1\] VGND VGND VPWR VPWR _1689_
+ sky130_fd_sc_hd__nand2_1
XFILLER_0_89_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2589_ _0581_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__clkbuf_4
X_2727_ RAM1.mem\[10\]\[5\] _0582_ _0497_ RAM1.mem\[11\]\[5\] _0428_ VGND VGND VPWR
+ VPWR _0719_ sky130_fd_sc_hd__a221o_1
X_2658_ _0595_ _0652_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__or2_1
X_4328_ clknet_leaf_6_clk _0116_ VGND VGND VPWR VPWR CPU1.RF1.rf\[1\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_4259_ clknet_leaf_0_clk net111 VGND VGND VPWR VPWR UART1.UART_RX1.state\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_100_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3630_ RAM1.mem\[19\]\[0\] _0455_ _1493_ VGND VGND VPWR VPWR _1494_ sky130_fd_sc_hd__mux2_1
X_3561_ _1445_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__clkbuf_1
X_2512_ _0535_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__clkbuf_1
X_2443_ _0407_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__buf_4
XFILLER_0_59_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3492_ _1396_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__clkbuf_1
X_2374_ net15 uart_curr_state\[1\] _2090_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__and3_2
X_4044_ _1785_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__clkbuf_1
X_4113_ _1838_ _0404_ _1828_ VGND VGND VPWR VPWR _1839_ sky130_fd_sc_hd__mux2_1
XFILLER_0_93_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3759_ _1580_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__clkbuf_1
X_3828_ _0452_ _1628_ _1614_ VGND VGND VPWR VPWR _1629_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_274 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_23 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2992_ _2061_ _0932_ _0936_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__nor3_4
XFILLER_0_45_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4593_ clknet_leaf_25_clk _0370_ VGND VGND VPWR VPWR UART1.UART_TX1.clkCount\[4\]
+ sky130_fd_sc_hd__dfxtp_2
XFILLER_0_3_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3613_ _1482_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_101_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3544_ _0414_ RAM1.mem\[20\]\[7\] _1417_ VGND VGND VPWR VPWR _1433_ sky130_fd_sc_hd__mux2_1
X_2426_ _0469_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3475_ _2108_ RAM1.mem\[9\]\[2\] _1378_ VGND VGND VPWR VPWR _1385_ sky130_fd_sc_hd__mux2_1
X_2288_ _2069_ _2072_ VGND VGND VPWR VPWR _2073_ sky130_fd_sc_hd__nor2_2
X_4027_ _1773_ VGND VGND VPWR VPWR _1774_ sky130_fd_sc_hd__clkbuf_4
X_2357_ _0409_ _0411_ _2099_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__mux2_1
XFILLER_0_66_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_231 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_72_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3260_ RAM1.mem\[4\]\[1\] RAM1.mem\[5\]\[1\] _1155_ VGND VGND VPWR VPWR _1187_ sky130_fd_sc_hd__mux2_1
XTAP_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3191_ _1118_ VGND VGND VPWR VPWR _1119_ sky130_fd_sc_hd__buf_4
X_2211_ UART1.UART_RX1.state\[0\] VGND VGND VPWR VPWR _2007_ sky130_fd_sc_hd__inv_2
X_2142_ _1936_ _1944_ VGND VGND VPWR VPWR _1945_ sky130_fd_sc_hd__or2_1
X_2975_ _0901_ _0911_ _0919_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__a21o_1
XFILLER_0_16_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3527_ _1421_ _2105_ _1419_ VGND VGND VPWR VPWR _1422_ sky130_fd_sc_hd__mux2_1
X_4576_ clknet_leaf_20_clk _0353_ VGND VGND VPWR VPWR RAM1.mem\[12\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_24_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2409_ _0454_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__clkbuf_1
X_3458_ _2062_ _1306_ VGND VGND VPWR VPWR _1373_ sky130_fd_sc_hd__nand2_1
X_3389_ _1154_ _1310_ VGND VGND VPWR VPWR _1311_ sky130_fd_sc_hd__or2_1
Xhold71 UART1.UART_RX1.dataOut\[7\] VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__dlygate4sd3_1
Xhold82 _1715_ VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__dlygate4sd3_1
Xhold93 UART1.RX_dataOut\[7\] VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__dlygate4sd3_1
Xhold60 UART1.RX_dataOut\[1\] VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__buf_1
XFILLER_0_38_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2691_ _0595_ _0684_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__or2_1
XANTENNA_2 _0392_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2760_ _0588_ _0748_ _0750_ _0599_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__o211a_1
XFILLER_0_53_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4430_ clknet_leaf_19_clk _0209_ VGND VGND VPWR VPWR RAM1.mem\[18\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_13_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4361_ clknet_leaf_3_clk _0140_ VGND VGND VPWR VPWR CPU1.PC1.pc_out\[2\] sky130_fd_sc_hd__dfxtp_2
X_3243_ _1117_ _1167_ _1169_ _1125_ VGND VGND VPWR VPWR _1170_ sky130_fd_sc_hd__o211a_1
XTAP_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3312_ RAM1.mem\[15\]\[3\] _2075_ VGND VGND VPWR VPWR _1237_ sky130_fd_sc_hd__or2_1
XTAP_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_47 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4292_ clknet_leaf_0_clk _0083_ VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__dfxtp_1
XTAP_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3174_ net69 _1094_ _1105_ _1092_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__o211a_1
XPHY_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2125_ _1931_ net155 VGND VGND VPWR VPWR _1932_ sky130_fd_sc_hd__nand2_4
X_2958_ _0902_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_29_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2889_ CPU1.instr_reg_out\[6\] CPU1.curr_state\[2\] VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__and2_2
X_4559_ clknet_leaf_20_clk _0336_ VGND VGND VPWR VPWR RAM1.mem\[13\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3930_ _1692_ _1702_ VGND VGND VPWR VPWR _1703_ sky130_fd_sc_hd__nand2_1
X_3792_ _1603_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__clkbuf_1
X_2743_ _0733_ _0734_ _0579_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__mux2_1
X_3861_ _1652_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__clkbuf_1
X_2812_ UART1.UART_RX1.clkCount\[0\] _0799_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__and2b_1
XFILLER_0_78_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4413_ clknet_leaf_14_clk _0192_ VGND VGND VPWR VPWR RAM1.mem\[20\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_2674_ _0615_ _0668_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__or2_1
X_4344_ clknet_leaf_2_clk _0017_ VGND VGND VPWR VPWR UART1.UART_TX1.state\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_26_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3157_ _0903_ VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__clkbuf_4
X_3226_ _2077_ VGND VGND VPWR VPWR _1154_ sky130_fd_sc_hd__buf_2
X_4275_ clknet_leaf_1_clk _0066_ VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__dfxtp_2
X_3088_ CPU1.reg_a_out\[7\] _0903_ _0904_ CPU1.PC1.pc_out\[7\] VGND VGND VPWR VPWR
+ _1029_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_64_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4060_ CPU1.RF1.rf\[0\]\[1\] _1792_ VGND VGND VPWR VPWR _1798_ sky130_fd_sc_hd__or2_1
X_2390_ _0392_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__clkbuf_4
X_3011_ _0926_ _0954_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3913_ UART1.UART_RX1.index\[0\] VGND VGND VPWR VPWR _1688_ sky130_fd_sc_hd__buf_2
X_3844_ _1640_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__clkbuf_1
X_3775_ _1377_ _1571_ VGND VGND VPWR VPWR _1591_ sky130_fd_sc_hd__nand2_4
XFILLER_0_73_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2726_ net43 _0575_ _0717_ _0718_ _0623_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__o221a_1
X_4327_ clknet_leaf_6_clk _0115_ VGND VGND VPWR VPWR CPU1.RF1.rf\[1\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_2657_ RAM1.mem\[8\]\[2\] RAM1.mem\[9\]\[2\] _0596_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__mux2_1
X_2588_ RAM1.mem\[10\]\[0\] _0582_ _0583_ RAM1.mem\[11\]\[0\] _0584_ VGND VGND VPWR
+ VPWR _0585_ sky130_fd_sc_hd__a221o_1
X_3209_ _0458_ VGND VGND VPWR VPWR _1137_ sky130_fd_sc_hd__clkbuf_4
X_4189_ _1952_ _1899_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__nor2_1
X_4258_ clknet_leaf_21_clk _0053_ VGND VGND VPWR VPWR RAM1.mem\[11\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_96_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_34_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3560_ _0440_ _1444_ _1438_ VGND VGND VPWR VPWR _1445_ sky130_fd_sc_hd__mux2_1
XFILLER_0_50_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2511_ _0446_ _0534_ _0524_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__mux2_1
X_2373_ _0425_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__buf_2
X_3491_ _1395_ _0417_ _1381_ VGND VGND VPWR VPWR _1396_ sky130_fd_sc_hd__mux2_1
X_2442_ _0481_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4043_ _0405_ _1784_ _1774_ VGND VGND VPWR VPWR _1785_ sky130_fd_sc_hd__mux2_1
X_4112_ _0402_ RAM1.mem\[12\]\[5\] _1826_ VGND VGND VPWR VPWR _1838_ sky130_fd_sc_hd__mux2_1
XFILLER_0_78_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3758_ _0437_ _1579_ _1575_ VGND VGND VPWR VPWR _1580_ sky130_fd_sc_hd__mux2_1
X_3689_ _0434_ _1535_ _1533_ VGND VGND VPWR VPWR _1536_ sky130_fd_sc_hd__mux2_1
X_3827_ RAM1.mem\[6\]\[7\] _0413_ _1611_ VGND VGND VPWR VPWR _1628_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2709_ _0579_ _0696_ _0697_ _0701_ _2093_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__a311o_1
XFILLER_0_34_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_286 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_84_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_284 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_77_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2991_ _0935_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3543_ _1432_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_51_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4592_ clknet_leaf_25_clk _0369_ VGND VGND VPWR VPWR UART1.UART_TX1.clkCount\[3\]
+ sky130_fd_sc_hd__dfxtp_2
XFILLER_0_16_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3612_ _1481_ _0387_ _1477_ VGND VGND VPWR VPWR _1482_ sky130_fd_sc_hd__mux2_1
X_3474_ _1384_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__clkbuf_1
X_2425_ _0468_ _2105_ _0465_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__mux2_1
X_2356_ _0410_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__clkbuf_4
X_2287_ _2070_ _2071_ VGND VGND VPWR VPWR _2072_ sky130_fd_sc_hd__nand2_2
X_4026_ _1380_ _1671_ VGND VGND VPWR VPWR _1773_ sky130_fd_sc_hd__or2_1
XFILLER_0_51_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3190_ _0458_ VGND VGND VPWR VPWR _1118_ sky130_fd_sc_hd__buf_4
X_2210_ _2003_ _2006_ _1952_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__a21oi_1
X_2141_ _1931_ uart_curr_state\[2\] VGND VGND VPWR VPWR _1944_ sky130_fd_sc_hd__and2_2
X_2974_ _0913_ _0914_ _0916_ _0918_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__o211a_1
XFILLER_0_56_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3526_ _2102_ RAM1.mem\[20\]\[1\] _1417_ VGND VGND VPWR VPWR _1421_ sky130_fd_sc_hd__mux2_1
X_4575_ clknet_leaf_20_clk _0352_ VGND VGND VPWR VPWR RAM1.mem\[12\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_21_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2408_ _0452_ _0453_ _0432_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__mux2_1
X_3457_ CPU1.instr_reg_out\[5\] VGND VGND VPWR VPWR _1372_ sky130_fd_sc_hd__clkbuf_4
X_3388_ RAM1.mem\[22\]\[6\] RAM1.mem\[23\]\[6\] _1137_ VGND VGND VPWR VPWR _1310_
+ sky130_fd_sc_hd__mux2_1
X_2339_ _0395_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__buf_4
X_4009_ _0393_ _1760_ _1754_ VGND VGND VPWR VPWR _1761_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_251 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold50 CPU1.RF1.rf\[1\]\[5\] VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__dlygate4sd3_1
Xhold94 CPU1.curr_state\[1\] VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__dlygate4sd3_1
Xhold72 UART1.UART_TX1.packet\[7\] VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__dlygate4sd3_1
Xhold61 _1712_ VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__dlygate4sd3_1
Xhold83 UART1.RX_dataOut\[0\] VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_42_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2690_ RAM1.mem\[0\]\[3\] RAM1.mem\[1\]\[3\] _0596_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__mux2_1
XANTENNA_3 _0464_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4360_ clknet_leaf_3_clk _0139_ VGND VGND VPWR VPWR CPU1.PC1.pc_out\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3311_ RAM1.mem\[12\]\[3\] RAM1.mem\[13\]\[3\] _1118_ VGND VGND VPWR VPWR _1236_
+ sky130_fd_sc_hd__mux2_1
X_3173_ _1094_ _1013_ VGND VGND VPWR VPWR _1105_ sky130_fd_sc_hd__nand2_1
X_3242_ _1121_ _1168_ VGND VGND VPWR VPWR _1169_ sky130_fd_sc_hd__or2_1
X_4291_ clknet_leaf_1_clk _0082_ VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__dfxtp_2
XTAP_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2124_ UART1.RX_done VGND VGND VPWR VPWR _1931_ sky130_fd_sc_hd__buf_4
XTAP_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2888_ _0848_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__buf_2
X_2957_ _2028_ _0828_ _0898_ VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__a21o_1
XFILLER_0_44_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3509_ _0396_ RAM1.mem\[21\]\[4\] _1398_ VGND VGND VPWR VPWR _1409_ sky130_fd_sc_hd__mux2_1
X_4489_ clknet_leaf_12_clk _0268_ VGND VGND VPWR VPWR RAM1.mem\[5\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_4558_ clknet_leaf_9_clk _0335_ VGND VGND VPWR VPWR RAM1.mem\[14\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput40 net40 VGND VGND VPWR VPWR tx_reg[1] sky130_fd_sc_hd__clkbuf_4
XPHY_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3791_ _0443_ _1602_ _1594_ VGND VGND VPWR VPWR _1603_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3860_ _1650_ _2087_ _1651_ VGND VGND VPWR VPWR _1652_ sky130_fd_sc_hd__mux2_1
X_2811_ _2003_ _2023_ _0798_ _1951_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__a31oi_4
X_2742_ RAM1.mem\[18\]\[5\] RAM1.mem\[19\]\[5\] _0612_ VGND VGND VPWR VPWR _0734_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_78_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4412_ clknet_leaf_13_clk _0191_ VGND VGND VPWR VPWR RAM1.mem\[20\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_2673_ _0666_ _0667_ _0578_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4274_ clknet_leaf_1_clk _0065_ VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__dfxtp_1
X_4343_ clknet_leaf_23_clk _0006_ VGND VGND VPWR VPWR UART1.UART_TX1.state\[1\] sky130_fd_sc_hd__dfxtp_1
X_3087_ _0961_ _1017_ VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__or2_1
X_3225_ _1116_ _1150_ _1152_ _2069_ VGND VGND VPWR VPWR _1153_ sky130_fd_sc_hd__a211o_1
X_3156_ net167 VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__inv_2
Xclkbuf_leaf_19_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_19_clk sky130_fd_sc_hd__clkbuf_16
X_3989_ _1705_ UART1.UART_RX1.index\[2\] _1731_ _1745_ UART1.UART_RX1.dataOut\[6\]
+ VGND VGND VPWR VPWR _1746_ sky130_fd_sc_hd__a32o_1
XFILLER_0_17_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_46 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3010_ net49 _0917_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3843_ _0440_ _1639_ _1633_ VGND VGND VPWR VPWR _1640_ sky130_fd_sc_hd__mux2_1
XFILLER_0_80_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3912_ _1687_ VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__clkbuf_1
X_3774_ _1590_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_73_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_8_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_8_clk sky130_fd_sc_hd__clkbuf_16
X_2725_ CPU1.PC1.pc_out\[4\] _1926_ _0575_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__a21bo_1
X_2656_ RAM1.mem\[12\]\[2\] RAM1.mem\[13\]\[2\] _0593_ VGND VGND VPWR VPWR _0651_
+ sky130_fd_sc_hd__mux2_1
X_4326_ clknet_leaf_7_clk _0114_ VGND VGND VPWR VPWR CPU1.RF1.rf\[1\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_2587_ _0427_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__buf_4
X_4257_ clknet_leaf_20_clk _0052_ VGND VGND VPWR VPWR RAM1.mem\[11\]\[6\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_1_151 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_89_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3139_ _1063_ _1067_ _1062_ VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__a21oi_1
X_4188_ _1873_ _1896_ _1897_ _1874_ _1898_ VGND VGND VPWR VPWR _1899_ sky130_fd_sc_hd__o32a_1
X_3208_ RAM1.mem\[10\]\[0\] RAM1.mem\[11\]\[0\] _1135_ VGND VGND VPWR VPWR _1136_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_87_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2510_ RAM1.mem\[22\]\[5\] _0479_ _0519_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__mux2_1
X_3490_ _0414_ RAM1.mem\[9\]\[7\] _1378_ VGND VGND VPWR VPWR _1395_ sky130_fd_sc_hd__mux2_1
XFILLER_0_59_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2372_ net16 uart_curr_state\[1\] _2090_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__and3_2
X_4111_ _1837_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__clkbuf_1
X_2441_ _0480_ _0405_ _0465_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__mux2_1
XFILLER_0_91_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4042_ _0479_ RAM1.mem\[13\]\[5\] _1771_ VGND VGND VPWR VPWR _1784_ sky130_fd_sc_hd__mux2_1
X_3826_ _1627_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3757_ _2108_ RAM1.mem\[4\]\[2\] _1572_ VGND VGND VPWR VPWR _1579_ sky130_fd_sc_hd__mux2_1
X_2639_ _0595_ _0634_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__or2_1
X_3688_ RAM1.mem\[2\]\[1\] _0467_ _1530_ VGND VGND VPWR VPWR _1535_ sky130_fd_sc_hd__mux2_1
X_2708_ _0605_ _0698_ _0700_ _0599_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__o211a_1
XFILLER_0_6_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4309_ clknet_leaf_24_clk _0097_ VGND VGND VPWR VPWR UART1.UART_RX1.clkCount\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_92_296 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_92_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2990_ net22 net21 _0933_ _0934_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__and4b_1
XFILLER_0_28_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3542_ _1431_ _0411_ _1419_ VGND VGND VPWR VPWR _1432_ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3473_ _1383_ _2105_ _1381_ VGND VGND VPWR VPWR _1384_ sky130_fd_sc_hd__mux2_1
X_4591_ clknet_leaf_25_clk _0368_ VGND VGND VPWR VPWR UART1.UART_TX1.clkCount\[2\]
+ sky130_fd_sc_hd__dfxtp_1
X_3611_ _2108_ RAM1.mem\[17\]\[2\] _1475_ VGND VGND VPWR VPWR _1481_ sky130_fd_sc_hd__mux2_1
X_2286_ _2061_ CPU1.PC1.pc_out\[3\] net53 CPU1.reg_b_out\[3\] VGND VGND VPWR VPWR
+ _2071_ sky130_fd_sc_hd__a22o_1
X_2355_ net35 _1941_ _2086_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__and3_2
X_2424_ RAM1.mem\[10\]\[1\] _0467_ _0462_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__mux2_1
X_4025_ _0455_ RAM1.mem\[13\]\[0\] _1771_ VGND VGND VPWR VPWR _1772_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3809_ RAM1.mem\[6\]\[1\] _2101_ _1611_ VGND VGND VPWR VPWR _1616_ sky130_fd_sc_hd__mux2_1
XFILLER_0_65_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2140_ UART1.TX_done uart_curr_state\[3\] net85 VGND VGND VPWR VPWR _1943_ sky130_fd_sc_hd__a21o_1
X_2973_ net49 _0917_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__or2_1
XFILLER_0_97_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4574_ clknet_leaf_4_clk _0351_ VGND VGND VPWR VPWR CPU1.reg_b_out\[7\] sky130_fd_sc_hd__dfxtp_1
X_3456_ _1365_ net159 _1366_ _1371_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__o211a_1
X_3525_ _1420_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_21_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2407_ _0414_ RAM1.mem\[0\]\[7\] _0423_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__mux2_1
X_2269_ _1946_ _2056_ VGND VGND VPWR VPWR _2057_ sky130_fd_sc_hd__and2_1
X_2338_ _2049_ CPU1.reg_a_out\[4\] _2065_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__and3_2
X_3387_ RAM1.mem\[20\]\[6\] RAM1.mem\[21\]\[6\] _1138_ VGND VGND VPWR VPWR _1309_
+ sky130_fd_sc_hd__mux2_1
X_4008_ RAM1.mem\[14\]\[3\] _0389_ _1751_ VGND VGND VPWR VPWR _1760_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold40 CPU1.RF1.rf\[2\]\[2\] VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dlygate4sd3_1
Xhold51 CPU1.alu_reg_out\[0\] VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__dlygate4sd3_1
Xhold95 UART1.UART_TX1.packet\[3\] VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__dlygate4sd3_1
Xhold73 UART1.UART_TX1.packet\[1\] VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__dlygate4sd3_1
Xhold84 UART1.UART_RX1.dataOut\[6\] VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__dlygate4sd3_1
Xhold62 UART1.UART_RX1.dataOut\[5\] VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_35 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_67_13 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XANTENNA_4 _0479_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4290_ clknet_leaf_0_clk _0081_ VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__dfxtp_1
X_3310_ _1134_ _1232_ _1234_ _2069_ VGND VGND VPWR VPWR _1235_ sky130_fd_sc_hd__a211o_2
X_3172_ net90 _1094_ _1104_ _1092_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__o211a_1
X_3241_ RAM1.mem\[22\]\[1\] RAM1.mem\[23\]\[1\] _1122_ VGND VGND VPWR VPWR _1168_
+ sky130_fd_sc_hd__mux2_1
X_2123_ net11 _1930_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__nor2_1
XTAP_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_263 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2887_ CPU1.instr_reg_out\[6\] CPU1.curr_state\[2\] VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__nand2_2
X_2956_ _0900_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__buf_2
XFILLER_0_32_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3508_ _1408_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__clkbuf_1
X_4488_ clknet_leaf_13_clk _0267_ VGND VGND VPWR VPWR RAM1.mem\[5\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_3439_ _1139_ _1357_ _1359_ _1190_ VGND VGND VPWR VPWR _1360_ sky130_fd_sc_hd__a211o_1
X_4557_ clknet_leaf_9_clk _0334_ VGND VGND VPWR VPWR RAM1.mem\[14\]\[6\] sky130_fd_sc_hd__dfxtp_1
Xoutput41 net41 VGND VGND VPWR VPWR tx_reg[2] sky130_fd_sc_hd__clkbuf_4
Xoutput30 net30 VGND VGND VPWR VPWR data_byte[1] sky130_fd_sc_hd__buf_2
XFILLER_0_85_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3790_ _0476_ RAM1.mem\[5\]\[4\] _1591_ VGND VGND VPWR VPWR _1602_ sky130_fd_sc_hd__mux2_1
X_4411_ clknet_leaf_14_clk _0190_ VGND VGND VPWR VPWR RAM1.mem\[20\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_2672_ RAM1.mem\[22\]\[2\] RAM1.mem\[23\]\[2\] _0592_ VGND VGND VPWR VPWR _0667_
+ sky130_fd_sc_hd__mux2_1
X_2741_ RAM1.mem\[16\]\[5\] RAM1.mem\[17\]\[5\] _0496_ VGND VGND VPWR VPWR _0733_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2810_ _2002_ UART1.UART_RX1.state\[1\] VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__or2b_1
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3224_ RAM1.mem\[0\]\[0\] _1137_ _2078_ _1151_ VGND VGND VPWR VPWR _1152_ sky130_fd_sc_hd__o211a_1
X_4273_ clknet_leaf_1_clk _0064_ VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__dfxtp_2
X_4342_ clknet_leaf_25_clk net56 VGND VGND VPWR VPWR UART1.UART_TX1.state\[0\] sky130_fd_sc_hd__dfxtp_1
.ends
